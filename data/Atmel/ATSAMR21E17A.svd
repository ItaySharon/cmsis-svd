<?xml version="1.0" encoding="UTF-8"?>
<device xmlns:xs="http://www.w3.org/2001/XMLSchema-instance" schemaVersion="1.1" xs:noNamespaceSchemaLocation="CMSIS-SVD_Schema_1_1.xsd"><access>read-write</access>
<addressUnitBits>0x8</addressUnitBits>
<cpu>
  <dcachePresent>
    <dcachePresen></dcachePresen>
  </dcachePresent>
  <deviceNumInterrupts>0x0</deviceNumInterrupts>
  <dtcmPresent>
    <dtcmPresen></dtcmPresen>
  </dtcmPresent>
  <endian>little</endian>
  <fpuPresent>0x0</fpuPresent>
  <icachePresent>
    <icachePresen></icachePresen>
  </icachePresent>
  <itcmPresent>
    <itcmPresen></itcmPresen>
  </itcmPresent>
  <mpuPresent>0x0</mpuPresent>
  <name>CM0+</name>
  <nvicPrioBits>0x2</nvicPrioBits>
  <revision>r0p1</revision>
  <sauNumRegions>0x0</sauNumRegions>
  <vendorSystickConfig>0x0</vendorSystickConfig>
  <vtorPresent>0x1</vtorPresent>
</cpu>
<description>Atmel ATSAMR21E17A device: Cortex-M0+ Microcontroller with 128KB Flash, 32KB SRAM, 233-pin package (refer to http://www.atmel.com/devices/SAMR21E17A.aspx for more)</description>
<name>ATSAMR21E17A</name>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42004400</baseAddress>
    <description>Analog Comparators</description>
    <groupName>AC</groupName>
    <interrupts>
      <interrupt>
        <name>AC_INTREQ</name>
        <value>0x18</value>
      </interrupt>
    </interrupts>
    <name>AC</name>
    <prependToName>AC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control A</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Low-Power Mux</description>
            <name>LPMUX</name>
          </field>
        </fields>
        <name>CTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0x1</addressOffset>
        <description>Control B</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 0 Start Comparison</description>
            <name>START0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 1 Start Comparison</description>
            <name>START1</name>
          </field>
        </fields>
        <name>CTRLB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2</addressOffset>
        <description>Event Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 0 Event Output Enable</description>
            <name>COMPEO0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 1 Event Output Enable</description>
            <name>COMPEO1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Window 0 Event Output Enable</description>
            <name>WINEO0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 0 Event Input</description>
            <name>COMPEI0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 1 Event Input</description>
            <name>COMPEI1</name>
          </field>
        </fields>
        <name>EVCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 0 Interrupt Enable</description>
            <name>COMP0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 1 Interrupt Enable</description>
            <name>COMP1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Window 0 Interrupt Enable</description>
            <name>WIN0</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x5</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 0 Interrupt Enable</description>
            <name>COMP0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 1 Interrupt Enable</description>
            <name>COMP1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Window 0 Interrupt Enable</description>
            <name>WIN0</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 0</description>
            <name>COMP0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 1</description>
            <name>COMP1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Window 0</description>
            <name>WIN0</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x8</addressOffset>
        <description>Status A</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 0 Current State</description>
            <name>STATE0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 1 Current State</description>
            <name>STATE1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Window 0 Current State</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Signal is above window</description>
                <name>ABOVE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Signal is inside window</description>
                <name>INSIDE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Signal is below window</description>
                <name>BELOW</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WSTATE0</name>
          </field>
        </fields>
        <name>STATUSA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x9</addressOffset>
        <description>Status B</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 0 Ready</description>
            <name>READY0</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 1 Ready</description>
            <name>READY1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Busy</description>
            <name>SYNCBUSY</name>
          </field>
        </fields>
        <name>STATUSB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xA</addressOffset>
        <description>Status C</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 0 Current State</description>
            <name>STATE0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Comparator 1 Current State</description>
            <name>STATE1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Window 0 Current State</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Signal is above window</description>
                <name>ABOVE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Signal is inside window</description>
                <name>INSIDE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Signal is below window</description>
                <name>BELOW</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WSTATE0</name>
          </field>
        </fields>
        <name>STATUSC</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xC</addressOffset>
        <description>Window Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Window 0 Mode Enable</description>
            <name>WEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Window 0 Interrupt Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on signal above window</description>
                <name>ABOVE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on signal inside window</description>
                <name>INSIDE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on signal below window</description>
                <name>BELOW</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on signal outside window</description>
                <name>OUTSIDE</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WINTSEL0</name>
          </field>
        </fields>
        <name>WINCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x10</addressOffset>
        <description>Comparator Control n</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Single-Shot Mode</description>
            <name>SINGLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Speed Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low speed</description>
                <name>LOW</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High speed</description>
                <name>HIGH</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SPEED</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Interrupt Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on comparator output toggle</description>
                <name>TOGGLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on comparator output rising</description>
                <name>RISING</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on comparator output falling</description>
                <name>FALLING</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on end of comparison (single-shot mode only)</description>
                <name>EOC</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>INTSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Negative Input Mux Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 0</description>
                <name>PIN0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 1</description>
                <name>PIN1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 2</description>
                <name>PIN2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 3</description>
                <name>PIN3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Ground</description>
                <name>GND</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>VDD scaler</description>
                <name>VSCALE</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Internal bandgap voltage</description>
                <name>BANDGAP</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>DAC output</description>
                <name>DAC</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>MUXNEG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Positive Input Mux Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 0</description>
                <name>PIN0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 1</description>
                <name>PIN1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 2</description>
                <name>PIN2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 3</description>
                <name>PIN3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>MUXPOS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap Inputs and Invert</description>
            <name>SWAP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Output</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>The output of COMPn is not routed to the COMPn I/O port</description>
                <name>OFF</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>The asynchronous output of COMPn is routed to the COMPn I/O port</description>
                <name>ASYNC</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>The synchronous output (including filtering) of COMPn is routed to the COMPn I/O port</description>
                <name>SYNC</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>OUT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Hysteresis Enable</description>
            <name>HYST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Filter Length</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No filtering</description>
                <name>OFF</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>3-bit majority function (2 of 3)</description>
                <name>MAJ3</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>5-bit majority function (3 of 5)</description>
                <name>MAJ5</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>FLEN</name>
          </field>
        </fields>
        <name>COMPCTRL0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14</addressOffset>
        <description>Comparator Control n</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Single-Shot Mode</description>
            <name>SINGLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Speed Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low speed</description>
                <name>LOW</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High speed</description>
                <name>HIGH</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SPEED</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Interrupt Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on comparator output toggle</description>
                <name>TOGGLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on comparator output rising</description>
                <name>RISING</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on comparator output falling</description>
                <name>FALLING</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Interrupt on end of comparison (single-shot mode only)</description>
                <name>EOC</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>INTSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Negative Input Mux Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 0</description>
                <name>PIN0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 1</description>
                <name>PIN1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 2</description>
                <name>PIN2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 3</description>
                <name>PIN3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Ground</description>
                <name>GND</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>VDD scaler</description>
                <name>VSCALE</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Internal bandgap voltage</description>
                <name>BANDGAP</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>DAC output</description>
                <name>DAC</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>MUXNEG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Positive Input Mux Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 0</description>
                <name>PIN0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 1</description>
                <name>PIN1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 2</description>
                <name>PIN2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O pin 3</description>
                <name>PIN3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>MUXPOS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap Inputs and Invert</description>
            <name>SWAP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Output</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>The output of COMPn is not routed to the COMPn I/O port</description>
                <name>OFF</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>The asynchronous output of COMPn is routed to the COMPn I/O port</description>
                <name>ASYNC</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>The synchronous output (including filtering) of COMPn is routed to the COMPn I/O port</description>
                <name>SYNC</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>OUT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Hysteresis Enable</description>
            <name>HYST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Filter Length</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No filtering</description>
                <name>OFF</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>3-bit majority function (2 of 3)</description>
                <name>MAJ3</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>5-bit majority function (3 of 5)</description>
                <name>MAJ5</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>FLEN</name>
          </field>
        </fields>
        <name>COMPCTRL1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x20</addressOffset>
        <description>Scaler n</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Scaler Value</description>
            <name>VALUE</name>
          </field>
        </fields>
        <name>SCALER0</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x21</addressOffset>
        <description>Scaler n</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Scaler Value</description>
            <name>VALUE</name>
          </field>
        </fields>
        <name>SCALER1</name>
        <size>0x8</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.1.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x80</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42004000</baseAddress>
    <description>Analog Digital Converter</description>
    <groupName>ADC</groupName>
    <interrupts>
      <interrupt>
        <name>ADC_INTREQ</name>
        <value>0x17</value>
      </interrupt>
    </interrupts>
    <name>ADC</name>
    <prependToName>ADC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control A</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <name>CTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1</addressOffset>
        <description>Reference Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Reference Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>1.0V voltage reference</description>
                <name>INT1V</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>1/1.48 VDDANA</description>
                <name>INTVCC0</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>1/2 VDDANA (only for VDDANA &gt; 2.0V)</description>
                <name>INTVCC1</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>External reference</description>
                <name>AREFA</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>External reference</description>
                <name>AREFB</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>REFSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Reference Buffer Offset Compensation Enable</description>
            <name>REFCOMP</name>
          </field>
        </fields>
        <name>REFCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2</addressOffset>
        <description>Average Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Number of Samples to be Collected</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>1 sample</description>
                <name>1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>2 samples</description>
                <name>2</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>4 samples</description>
                <name>4</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>8 samples</description>
                <name>8</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16 samples</description>
                <name>16</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>32 samples</description>
                <name>32</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>64 samples</description>
                <name>64</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>128 samples</description>
                <name>128</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>256 samples</description>
                <name>256</name>
                <value>0x8</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>512 samples</description>
                <name>512</name>
                <value>0x9</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>1024 samples</description>
                <name>1024</name>
                <value>0xA</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SAMPLENUM</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Adjusting Result / Division Coefficient</description>
            <name>ADJRES</name>
          </field>
        </fields>
        <name>AVGCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x3</addressOffset>
        <description>Sampling Time Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Sampling Time Length</description>
            <name>SAMPLEN</name>
          </field>
        </fields>
        <name>SAMPCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Control B</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Differential Mode</description>
            <name>DIFFMODE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Left-Adjusted Result</description>
            <name>LEFTADJ</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Free Running Mode</description>
            <name>FREERUN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Digital Correction Logic Enabled</description>
            <name>CORREN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Conversion Result Resolution</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>12-bit result</description>
                <name>12BIT</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>For averaging mode output</description>
                <name>16BIT</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>10-bit result</description>
                <name>10BIT</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>8-bit result</description>
                <name>8BIT</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RESSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Prescaler Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral clock divided by 4</description>
                <name>DIV4</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral clock divided by 8</description>
                <name>DIV8</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral clock divided by 16</description>
                <name>DIV16</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral clock divided by 32</description>
                <name>DIV32</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral clock divided by 64</description>
                <name>DIV64</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral clock divided by 128</description>
                <name>DIV128</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral clock divided by 256</description>
                <name>DIV256</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral clock divided by 512</description>
                <name>DIV512</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PRESCALER</name>
          </field>
        </fields>
        <name>CTRLB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>Window Monitor Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Window Monitor Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No window mode (default)</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Mode 1: RESULT &gt; WINLT</description>
                <name>MODE1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Mode 2: RESULT &lt; WINUT</description>
                <name>MODE2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Mode 3: WINLT &lt; RESULT &lt; WINUT</description>
                <name>MODE3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Mode 4: !(WINLT &lt; RESULT &lt; WINUT)</description>
                <name>MODE4</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WINMODE</name>
          </field>
        </fields>
        <name>WINCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xC</addressOffset>
        <description>Software Trigger</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>ADC Conversion Flush</description>
            <name>FLUSH</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>ADC Start Conversion</description>
            <name>START</name>
          </field>
        </fields>
        <name>SWTRIG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x10</addressOffset>
        <description>Input Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Positive Mux Input Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN0 Pin</description>
                <name>PIN0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN1 Pin</description>
                <name>PIN1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN2 Pin</description>
                <name>PIN2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN3 Pin</description>
                <name>PIN3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN4 Pin</description>
                <name>PIN4</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN5 Pin</description>
                <name>PIN5</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN6 Pin</description>
                <name>PIN6</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN7 Pin</description>
                <name>PIN7</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN8 Pin</description>
                <name>PIN8</name>
                <value>0x8</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN9 Pin</description>
                <name>PIN9</name>
                <value>0x9</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN10 Pin</description>
                <name>PIN10</name>
                <value>0xA</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN11 Pin</description>
                <name>PIN11</name>
                <value>0xB</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN12 Pin</description>
                <name>PIN12</name>
                <value>0xC</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN13 Pin</description>
                <name>PIN13</name>
                <value>0xD</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN14 Pin</description>
                <name>PIN14</name>
                <value>0xE</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN15 Pin</description>
                <name>PIN15</name>
                <value>0xF</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN16 Pin</description>
                <name>PIN16</name>
                <value>0x10</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN17 Pin</description>
                <name>PIN17</name>
                <value>0x11</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN18 Pin</description>
                <name>PIN18</name>
                <value>0x12</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN19 Pin</description>
                <name>PIN19</name>
                <value>0x13</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Temperature Reference</description>
                <name>TEMP</name>
                <value>0x18</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Bandgap Voltage</description>
                <name>BANDGAP</name>
                <value>0x19</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>1/4  Scaled Core Supply</description>
                <name>SCALEDCOREVCC</name>
                <value>0x1A</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>1/4  Scaled I/O Supply</description>
                <name>SCALEDIOVCC</name>
                <value>0x1B</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>DAC Output</description>
                <name>DAC</name>
                <value>0x1C</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>MUXPOS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Negative Mux Input Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN0 Pin</description>
                <name>PIN0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN1 Pin</description>
                <name>PIN1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN2 Pin</description>
                <name>PIN2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN3 Pin</description>
                <name>PIN3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN4 Pin</description>
                <name>PIN4</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN5 Pin</description>
                <name>PIN5</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN6 Pin</description>
                <name>PIN6</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC AIN7 Pin</description>
                <name>PIN7</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Internal Ground</description>
                <name>GND</name>
                <value>0x18</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O Ground</description>
                <name>IOGND</name>
                <value>0x19</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>MUXNEG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Number of Input Channels Included in Scan</description>
            <name>INPUTSCAN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x14</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Positive Mux Setting Offset</description>
            <name>INPUTOFFSET</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Gain Factor Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>1x</description>
                <name>1X</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>2x</description>
                <name>2X</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>4x</description>
                <name>4X</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>8x</description>
                <name>8X</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16x</description>
                <name>16X</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>1/2x</description>
                <name>DIV2</name>
                <value>0xF</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>GAIN</name>
          </field>
        </fields>
        <name>INPUTCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x14</addressOffset>
        <description>Event Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Start Conversion Event In</description>
            <name>STARTEI</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Event In</description>
            <name>SYNCEI</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Result Ready Event Out</description>
            <name>RESRDYEO</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Window Monitor Event Out</description>
            <name>WINMONEO</name>
          </field>
        </fields>
        <name>EVCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x16</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Result Ready Interrupt Enable</description>
            <name>RESRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overrun Interrupt Enable</description>
            <name>OVERRUN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Window Monitor Interrupt Enable</description>
            <name>WINMON</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Ready Interrupt Enable</description>
            <name>SYNCRDY</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x17</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Result Ready Interrupt Enable</description>
            <name>RESRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overrun Interrupt Enable</description>
            <name>OVERRUN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Window Monitor Interrupt Enable</description>
            <name>WINMON</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Ready Interrupt Enable</description>
            <name>SYNCRDY</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x18</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Result Ready</description>
            <name>RESRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overrun</description>
            <name>OVERRUN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Window Monitor</description>
            <name>WINMON</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Ready</description>
            <name>SYNCRDY</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x19</addressOffset>
        <description>Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Busy</description>
            <name>SYNCBUSY</name>
          </field>
        </fields>
        <name>STATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1A</addressOffset>
        <description>Result</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Result Conversion Value</description>
            <name>RESULT</name>
          </field>
        </fields>
        <name>RESULT</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1C</addressOffset>
        <description>Window Monitor Lower Threshold</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Window Lower Threshold</description>
            <name>WINLT</name>
          </field>
        </fields>
        <name>WINLT</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x20</addressOffset>
        <description>Window Monitor Upper Threshold</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Window Upper Threshold</description>
            <name>WINUT</name>
          </field>
        </fields>
        <name>WINUT</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x24</addressOffset>
        <description>Gain Correction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0xC</bitWidth>
            <description>Gain Correction Value</description>
            <name>GAINCORR</name>
          </field>
        </fields>
        <name>GAINCORR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x26</addressOffset>
        <description>Offset Correction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0xC</bitWidth>
            <description>Offset Correction Value</description>
            <name>OFFSETCORR</name>
          </field>
        </fields>
        <name>OFFSETCORR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x28</addressOffset>
        <description>Calibration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Linearity Calibration Value</description>
            <name>LINEARITY_CAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Bias Calibration Value</description>
            <name>BIAS_CAL</name>
          </field>
        </fields>
        <name>CALIB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2A</addressOffset>
        <description>Debug Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Debug Run</description>
            <name>DBGRUN</name>
          </field>
        </fields>
        <name>DBGCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.2.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x10</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42004800</baseAddress>
    <description>Digital Analog Converter</description>
    <groupName>DAC</groupName>
    <interrupts>
      <interrupt>
        <name>DAC_INTREQ</name>
        <value>0x19</value>
      </interrupt>
    </interrupts>
    <name>DAC</name>
    <prependToName>DAC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control A</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <name>CTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1</addressOffset>
        <description>Control B</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Output Enable</description>
            <name>EOEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Internal Output Enable</description>
            <name>IOEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Left Adjusted Data</description>
            <name>LEFTADJ</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Voltage Pump Disable</description>
            <name>VPD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Bypass DATABUF Write Protection</description>
            <name>BDWP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Reference Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Internal 1.0V reference</description>
                <name>INT1V</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>AVCC</description>
                <name>AVCC</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>External reference</description>
                <name>VREFP</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>REFSEL</name>
          </field>
        </fields>
        <name>CTRLB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2</addressOffset>
        <description>Event Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Start Conversion Event Input</description>
            <name>STARTEI</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Data Buffer Empty Event Output</description>
            <name>EMPTYEO</name>
          </field>
        </fields>
        <name>EVCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Underrun Interrupt Enable</description>
            <name>UNDERRUN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Data Buffer Empty Interrupt Enable</description>
            <name>EMPTY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Ready Interrupt Enable</description>
            <name>SYNCRDY</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x5</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Underrun Interrupt Enable</description>
            <name>UNDERRUN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Data Buffer Empty Interrupt Enable</description>
            <name>EMPTY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Ready Interrupt Enable</description>
            <name>SYNCRDY</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Underrun</description>
            <name>UNDERRUN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Data Buffer Empty</description>
            <name>EMPTY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Ready</description>
            <name>SYNCRDY</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x7</addressOffset>
        <description>Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Busy Status</description>
            <name>SYNCBUSY</name>
          </field>
        </fields>
        <name>STATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>Data</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Data value to be converted</description>
            <name>DATA</name>
          </field>
        </fields>
        <name>DATA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xC</addressOffset>
        <description>Data Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Data Buffer</description>
            <name>DATABUF</name>
          </field>
        </fields>
        <name>DATABUF</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.1.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x80</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x41004800</baseAddress>
    <description>Direct Memory Access Controller</description>
    <groupName>DMAC</groupName>
    <interrupts>
      <interrupt>
        <name>DMAC_INTREQ</name>
        <value>0x6</value>
      </interrupt>
    </interrupts>
    <name>DMAC</name>
    <prependToName>DMAC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DMA Enable</description>
            <name>DMAENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>CRC Enable</description>
            <name>CRCENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Priority Level 0 Enable</description>
            <name>LVLEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Priority Level 1 Enable</description>
            <name>LVLEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Priority Level 2 Enable</description>
            <name>LVLEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Priority Level 3 Enable</description>
            <name>LVLEN3</name>
          </field>
        </fields>
        <name>CTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2</addressOffset>
        <description>CRC Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>CRC Beat Size</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>8-bit bus transfer</description>
                <name>BYTE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16-bit bus transfer</description>
                <name>HWORD</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>32-bit bus transfer</description>
                <name>WORD</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CRCBEATSIZE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>CRC Polynomial Type</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>CRC-16 (CRC-CCITT)</description>
                <name>CRC16</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>CRC32 (IEEE 802.3)</description>
                <name>CRC32</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CRCPOLY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>CRC Input Source</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No action</description>
                <name>NOACT</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I/O interface</description>
                <name>IO</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CRCSRC</name>
          </field>
        </fields>
        <name>CRCCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>CRC Data Input</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>CRC Data Input</description>
            <name>CRCDATAIN</name>
          </field>
        </fields>
        <name>CRCDATAIN</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>CRC Checksum</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>CRC Checksum</description>
            <name>CRCCHKSUM</name>
          </field>
        </fields>
        <name>CRCCHKSUM</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xC</addressOffset>
        <description>CRC Status</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>CRC Module Busy</description>
            <name>CRCBUSY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>CRC Zero</description>
            <name>CRCZERO</name>
          </field>
        </fields>
        <name>CRCSTATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xD</addressOffset>
        <description>Debug Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Debug Run</description>
            <name>DBGRUN</name>
          </field>
        </fields>
        <name>DBGCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xE</addressOffset>
        <description>QOS Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Write-Back Quality of Service</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Background (no sensitive operation)</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Sensitive Bandwidth</description>
                <name>LOW</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Sensitive Latency</description>
                <name>MEDIUM</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Critical Latency</description>
                <name>HIGH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WRBQOS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fetch Quality of Service</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Background (no sensitive operation)</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Sensitive Bandwidth</description>
                <name>LOW</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Sensitive Latency</description>
                <name>MEDIUM</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Critical Latency</description>
                <name>HIGH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>FQOS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Data Transfer Quality of Service</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Background (no sensitive operation)</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Sensitive Bandwidth</description>
                <name>LOW</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Sensitive Latency</description>
                <name>MEDIUM</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Critical Latency</description>
                <name>HIGH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>DQOS</name>
          </field>
        </fields>
        <name>QOSCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x15</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x10</addressOffset>
        <description>Software Trigger Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Software Trigger</description>
            <name>SWTRIG0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Software Trigger</description>
            <name>SWTRIG1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Software Trigger</description>
            <name>SWTRIG2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Software Trigger</description>
            <name>SWTRIG3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 4 Software Trigger</description>
            <name>SWTRIG4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 5 Software Trigger</description>
            <name>SWTRIG5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 6 Software Trigger</description>
            <name>SWTRIG6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 7 Software Trigger</description>
            <name>SWTRIG7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 8 Software Trigger</description>
            <name>SWTRIG8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 9 Software Trigger</description>
            <name>SWTRIG9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 10 Software Trigger</description>
            <name>SWTRIG10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 11 Software Trigger</description>
            <name>SWTRIG11</name>
          </field>
        </fields>
        <name>SWTRIGCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x14</addressOffset>
        <description>Priority Control 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Level 0 Channel Priority Number</description>
            <name>LVLPRI0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Level 0 Round-Robin Scheduling Enable</description>
            <name>RRLVLEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Level 1 Channel Priority Number</description>
            <name>LVLPRI1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Level 1 Round-Robin Scheduling Enable</description>
            <name>RRLVLEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Level 2 Channel Priority Number</description>
            <name>LVLPRI2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x17</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Level 2 Round-Robin Scheduling Enable</description>
            <name>RRLVLEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Level 3 Channel Priority Number</description>
            <name>LVLPRI3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Level 3 Round-Robin Scheduling Enable</description>
            <name>RRLVLEN3</name>
          </field>
        </fields>
        <name>PRICTRL0</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x20</addressOffset>
        <description>Interrupt Pending</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Channel ID</description>
            <name>ID</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Transfer Error</description>
            <name>TERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Transfer Complete</description>
            <name>TCMPL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Suspend</description>
            <name>SUSP</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fetch Error</description>
            <name>FERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy</description>
            <name>BUSY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending</description>
            <name>PEND</name>
          </field>
        </fields>
        <name>INTPEND</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x24</addressOffset>
        <description>Interrupt Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Pending Interrupt</description>
            <name>CHINT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Pending Interrupt</description>
            <name>CHINT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Pending Interrupt</description>
            <name>CHINT2</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Pending Interrupt</description>
            <name>CHINT3</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 4 Pending Interrupt</description>
            <name>CHINT4</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 5 Pending Interrupt</description>
            <name>CHINT5</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 6 Pending Interrupt</description>
            <name>CHINT6</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 7 Pending Interrupt</description>
            <name>CHINT7</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 8 Pending Interrupt</description>
            <name>CHINT8</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 9 Pending Interrupt</description>
            <name>CHINT9</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 10 Pending Interrupt</description>
            <name>CHINT10</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 11 Pending Interrupt</description>
            <name>CHINT11</name>
          </field>
        </fields>
        <name>INTSTATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x28</addressOffset>
        <description>Busy Channels</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 0</description>
            <name>BUSYCH0</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 1</description>
            <name>BUSYCH1</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 2</description>
            <name>BUSYCH2</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 3</description>
            <name>BUSYCH3</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 4</description>
            <name>BUSYCH4</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 5</description>
            <name>BUSYCH5</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 6</description>
            <name>BUSYCH6</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 7</description>
            <name>BUSYCH7</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 8</description>
            <name>BUSYCH8</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 9</description>
            <name>BUSYCH9</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 10</description>
            <name>BUSYCH10</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Busy Channel 11</description>
            <name>BUSYCH11</name>
          </field>
        </fields>
        <name>BUSYCH</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x2C</addressOffset>
        <description>Pending Channels</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 0</description>
            <name>PENDCH0</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 1</description>
            <name>PENDCH1</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 2</description>
            <name>PENDCH2</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 3</description>
            <name>PENDCH3</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 4</description>
            <name>PENDCH4</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 5</description>
            <name>PENDCH5</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 6</description>
            <name>PENDCH6</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 7</description>
            <name>PENDCH7</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 8</description>
            <name>PENDCH8</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 9</description>
            <name>PENDCH9</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 10</description>
            <name>PENDCH10</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pending Channel 11</description>
            <name>PENDCH11</name>
          </field>
        </fields>
        <name>PENDCH</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x30</addressOffset>
        <description>Active Channel and Levels</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Level 0 Channel Trigger Request Executing</description>
            <name>LVLEX0</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Level 1 Channel Trigger Request Executing</description>
            <name>LVLEX1</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Level 2 Channel Trigger Request Executing</description>
            <name>LVLEX2</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Level 3 Channel Trigger Request Executing</description>
            <name>LVLEX3</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Active Channel ID</description>
            <name>ID</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Active Channel Busy</description>
            <name>ABUSY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Active Channel Block Transfer Count</description>
            <name>BTCNT</name>
          </field>
        </fields>
        <name>ACTIVE</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Descriptor Memory Section Base Address</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Descriptor Memory Base Address</description>
            <name>BASEADDR</name>
          </field>
        </fields>
        <name>BASEADDR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x38</addressOffset>
        <description>Write-Back Memory Section Base Address</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Write-Back Memory Base Address</description>
            <name>WRBADDR</name>
          </field>
        </fields>
        <name>WRBADDR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x3F</addressOffset>
        <description>Channel ID</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Channel ID</description>
            <name>ID</name>
          </field>
        </fields>
        <name>CHID</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Channel Control A</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <name>CHCTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x44</addressOffset>
        <description>Channel Control B</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Event Input Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No action</description>
                <name>NOACT</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Transfer and periodic transfer trigger</description>
                <name>TRIG</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Conditional transfer trigger</description>
                <name>CTRIG</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Conditional block transfer</description>
                <name>CBLOCK</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Channel suspend operation</description>
                <name>SUSPEND</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Channel resume operation</description>
                <name>RESUME</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Skip next block suspend action</description>
                <name>SSKIP</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>EVACT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Event Input Enable</description>
            <name>EVIE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Event Output Enable</description>
            <name>EVOE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Channel Arbitration Level</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Channel Priority Level 0</description>
                <name>LVL0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Channel Priority Level 1</description>
                <name>LVL1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Channel Priority Level 2</description>
                <name>LVL2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Channel Priority Level 3</description>
                <name>LVL3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>LVL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Trigger Source</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Only software/event triggers</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>TRIGSRC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Trigger Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>One trigger required for each block transfer</description>
                <name>BLOCK</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>One trigger required for each beat transfer</description>
                <name>BEAT</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>One trigger required for each transaction</description>
                <name>TRANSACTION</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>TRIGACT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Software Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No action</description>
                <name>NOACT</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Channel suspend operation</description>
                <name>SUSPEND</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Channel resume operation</description>
                <name>RESUME</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CMD</name>
          </field>
        </fields>
        <name>CHCTRLB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4C</addressOffset>
        <description>Channel Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Transfer Error Interrupt Enable</description>
            <name>TERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Transfer Complete Interrupt Enable</description>
            <name>TCMPL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Suspend Interrupt Enable</description>
            <name>SUSP</name>
          </field>
        </fields>
        <name>CHINTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4D</addressOffset>
        <description>Channel Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Transfer Error Interrupt Enable</description>
            <name>TERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Transfer Complete Interrupt Enable</description>
            <name>TCMPL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Suspend Interrupt Enable</description>
            <name>SUSP</name>
          </field>
        </fields>
        <name>CHINTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4E</addressOffset>
        <description>Channel Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Transfer Error</description>
            <name>TERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Transfer Complete</description>
            <name>TCMPL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Suspend</description>
            <name>SUSP</name>
          </field>
        </fields>
        <name>CHINTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x4F</addressOffset>
        <description>Channel Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Pending</description>
            <name>PEND</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Busy</description>
            <name>BUSY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel Fetch Error</description>
            <name>FERR</name>
          </field>
        </fields>
        <name>CHSTATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x2000</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x41002000</baseAddress>
    <description>Device Service Unit</description>
    <groupName>DSU</groupName>
    <interrupts></interrupts>
    <name>DSU</name>
    <prependToName>DSU_</prependToName>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0x0</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>32-bit Cyclic Redundancy Check</description>
            <name>CRC</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Memory Built-In Self-Test</description>
            <name>MBIST</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Chip Erase</description>
            <name>CE</name>
          </field>
        </fields>
        <name>CTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1</addressOffset>
        <description>Status A</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Done</description>
            <name>DONE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>CPU Reset Phase Extension</description>
            <name>CRSTEXT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Bus Error</description>
            <name>BERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Failure</description>
            <name>FAIL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Protection Error</description>
            <name>PERR</name>
          </field>
        </fields>
        <name>STATUSA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x2</addressOffset>
        <description>Status B</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Protected</description>
            <name>PROT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Debugger Present</description>
            <name>DBGPRES</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Debug Communication Channel 0 Dirty</description>
            <name>DCCD0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Debug Communication Channel 1 Dirty</description>
            <name>DCCD1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Hot-Plugging Enable</description>
            <name>HPE</name>
          </field>
        </fields>
        <name>STATUSB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x10</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Address</description>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1E</bitWidth>
            <description>Address</description>
            <name>ADDR</name>
          </field>
        </fields>
        <name>ADDR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>Length</description>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1E</bitWidth>
            <description>Length</description>
            <name>LENGTH</name>
          </field>
        </fields>
        <name>LENGTH</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xC</addressOffset>
        <description>Data</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Data</description>
            <name>DATA</name>
          </field>
        </fields>
        <name>DATA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x18</addressOffset>
        <description>Device Identification</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Device Select</description>
            <name>DEVSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Revision</description>
            <name>REVISION</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Die Identification</description>
            <name>DIE</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Product Series</description>
            <name>SERIES</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x17</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Product Family</description>
            <name>FAMILY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Processor</description>
            <name>PROCESSOR</name>
          </field>
        </fields>
        <name>DID</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x1001031D</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1008</addressOffset>
        <description>Coresight ROM Table End</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>End Marker</description>
            <name>END</name>
          </field>
        </fields>
        <name>END</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1FCC</addressOffset>
        <description>Coresight ROM Table Memory Type</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>System Memory Present</description>
            <name>SMEMP</name>
          </field>
        </fields>
        <name>MEMTYPE</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1FD0</addressOffset>
        <description>Peripheral Identification 4</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>JEP-106 Continuation Code</description>
            <name>JEPCC</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>4KB Count</description>
            <name>FKBC</name>
          </field>
        </fields>
        <name>PID4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1FE0</addressOffset>
        <description>Peripheral Identification 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Part Number Low</description>
            <name>PARTNBL</name>
          </field>
        </fields>
        <name>PID0</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xD0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1FE4</addressOffset>
        <description>Peripheral Identification 1</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Part Number High</description>
            <name>PARTNBH</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Low part of the JEP-106 Identity Code</description>
            <name>JEPIDCL</name>
          </field>
        </fields>
        <name>PID1</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFC</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1FE8</addressOffset>
        <description>Peripheral Identification 2</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>JEP-106 Identity Code High</description>
            <name>JEPIDCH</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>JEP-106 Identity Code is used</description>
            <name>JEPU</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Revision Number</description>
            <name>REVISION</name>
          </field>
        </fields>
        <name>PID2</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x9</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1FEC</addressOffset>
        <description>Peripheral Identification 3</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>ARM CUSMOD</description>
            <name>CUSMOD</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Revision Number</description>
            <name>REVAND</name>
          </field>
        </fields>
        <name>PID3</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1FF0</addressOffset>
        <description>Component Identification 0</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Preamble Byte 0</description>
            <name>PREAMBLEB0</name>
          </field>
        </fields>
        <name>CID0</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xD</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1FF4</addressOffset>
        <description>Component Identification 1</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Preamble</description>
            <name>PREAMBLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Component Class</description>
            <name>CCLASS</name>
          </field>
        </fields>
        <name>CID1</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x10</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1FF8</addressOffset>
        <description>Component Identification 2</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Preamble Byte 2</description>
            <name>PREAMBLEB2</name>
          </field>
        </fields>
        <name>CID2</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x5</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1FFC</addressOffset>
        <description>Component Identification 3</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Preamble Byte 3</description>
            <name>PREAMBLEB3</name>
          </field>
        </fields>
        <name>CID3</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xB1</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x10</addressOffset>
        <description>Debug Communication Channel n</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Data</description>
            <name>DATA</name>
          </field>
        </fields>
        <name>DCC0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14</addressOffset>
        <description>Debug Communication Channel n</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Data</description>
            <name>DATA</name>
          </field>
        </fields>
        <name>DCC1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1000</addressOffset>
        <description>Coresight ROM Table Entry n</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Entry Present</description>
            <name>EPRES</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Format</description>
            <name>FMT</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Address Offset</description>
            <name>ADDOFF</name>
          </field>
        </fields>
        <name>ENTRY0</name>
        <resetValue>0x2</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1004</addressOffset>
        <description>Coresight ROM Table Entry n</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Entry Present</description>
            <name>EPRES</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Format</description>
            <name>FMT</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Address Offset</description>
            <name>ADDOFF</name>
          </field>
        </fields>
        <name>ENTRY1</name>
        <resetValue>0x2</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x40001800</baseAddress>
    <description>External Interrupt Controller</description>
    <groupName>EIC</groupName>
    <interrupts>
      <interrupt>
        <name>EIC_INTREQ</name>
        <value>0x4</value>
      </interrupt>
    </interrupts>
    <name>EIC</name>
    <prependToName>EIC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <name>CTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1</addressOffset>
        <description>Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Busy</description>
            <name>SYNCBUSY</name>
          </field>
        </fields>
        <name>STATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2</addressOffset>
        <description>Non-Maskable Interrupt Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Non-Maskable Interrupt Sense</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising-edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling-edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both-edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High-level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low-level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>NMISENSE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Maskable Interrupt Filter Enable</description>
            <name>NMIFILTEN</name>
          </field>
        </fields>
        <name>NMICTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x3</addressOffset>
        <description>Non-Maskable Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Maskable Interrupt</description>
            <name>NMI</name>
          </field>
        </fields>
        <name>NMIFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Event Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 0 Event Output Enable</description>
            <name>EXTINTEO0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 1 Event Output Enable</description>
            <name>EXTINTEO1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 2 Event Output Enable</description>
            <name>EXTINTEO2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 3 Event Output Enable</description>
            <name>EXTINTEO3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 4 Event Output Enable</description>
            <name>EXTINTEO4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 5 Event Output Enable</description>
            <name>EXTINTEO5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 6 Event Output Enable</description>
            <name>EXTINTEO6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 7 Event Output Enable</description>
            <name>EXTINTEO7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 8 Event Output Enable</description>
            <name>EXTINTEO8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 9 Event Output Enable</description>
            <name>EXTINTEO9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 10 Event Output Enable</description>
            <name>EXTINTEO10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 11 Event Output Enable</description>
            <name>EXTINTEO11</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 12 Event Output Enable</description>
            <name>EXTINTEO12</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 13 Event Output Enable</description>
            <name>EXTINTEO13</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 14 Event Output Enable</description>
            <name>EXTINTEO14</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 15 Event Output Enable</description>
            <name>EXTINTEO15</name>
          </field>
        </fields>
        <name>EVCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 0 Enable</description>
            <name>EXTINT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 1 Enable</description>
            <name>EXTINT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 2 Enable</description>
            <name>EXTINT2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 3 Enable</description>
            <name>EXTINT3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 4 Enable</description>
            <name>EXTINT4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 5 Enable</description>
            <name>EXTINT5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 6 Enable</description>
            <name>EXTINT6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 7 Enable</description>
            <name>EXTINT7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 8 Enable</description>
            <name>EXTINT8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 9 Enable</description>
            <name>EXTINT9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 10 Enable</description>
            <name>EXTINT10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 11 Enable</description>
            <name>EXTINT11</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 12 Enable</description>
            <name>EXTINT12</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 13 Enable</description>
            <name>EXTINT13</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 14 Enable</description>
            <name>EXTINT14</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 15 Enable</description>
            <name>EXTINT15</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xC</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 0 Enable</description>
            <name>EXTINT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 1 Enable</description>
            <name>EXTINT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 2 Enable</description>
            <name>EXTINT2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 3 Enable</description>
            <name>EXTINT3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 4 Enable</description>
            <name>EXTINT4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 5 Enable</description>
            <name>EXTINT5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 6 Enable</description>
            <name>EXTINT6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 7 Enable</description>
            <name>EXTINT7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 8 Enable</description>
            <name>EXTINT8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 9 Enable</description>
            <name>EXTINT9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 10 Enable</description>
            <name>EXTINT10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 11 Enable</description>
            <name>EXTINT11</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 12 Enable</description>
            <name>EXTINT12</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 13 Enable</description>
            <name>EXTINT13</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 14 Enable</description>
            <name>EXTINT14</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 15 Enable</description>
            <name>EXTINT15</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x10</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 0</description>
            <name>EXTINT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 1</description>
            <name>EXTINT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 2</description>
            <name>EXTINT2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 3</description>
            <name>EXTINT3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 4</description>
            <name>EXTINT4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 5</description>
            <name>EXTINT5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 6</description>
            <name>EXTINT6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 7</description>
            <name>EXTINT7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 8</description>
            <name>EXTINT8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 9</description>
            <name>EXTINT9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 10</description>
            <name>EXTINT10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 11</description>
            <name>EXTINT11</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 12</description>
            <name>EXTINT12</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 13</description>
            <name>EXTINT13</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 14</description>
            <name>EXTINT14</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 15</description>
            <name>EXTINT15</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x14</addressOffset>
        <description>Wake-Up Enable</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 0 Wake-up Enable</description>
            <name>WAKEUPEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 1 Wake-up Enable</description>
            <name>WAKEUPEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 2 Wake-up Enable</description>
            <name>WAKEUPEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 3 Wake-up Enable</description>
            <name>WAKEUPEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 4 Wake-up Enable</description>
            <name>WAKEUPEN4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 5 Wake-up Enable</description>
            <name>WAKEUPEN5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 6 Wake-up Enable</description>
            <name>WAKEUPEN6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 7 Wake-up Enable</description>
            <name>WAKEUPEN7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 8 Wake-up Enable</description>
            <name>WAKEUPEN8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 9 Wake-up Enable</description>
            <name>WAKEUPEN9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 10 Wake-up Enable</description>
            <name>WAKEUPEN10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 11 Wake-up Enable</description>
            <name>WAKEUPEN11</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 12 Wake-up Enable</description>
            <name>WAKEUPEN12</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 13 Wake-up Enable</description>
            <name>WAKEUPEN13</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 14 Wake-up Enable</description>
            <name>WAKEUPEN14</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Interrupt 15 Wake-up Enable</description>
            <name>WAKEUPEN15</name>
          </field>
        </fields>
        <name>WAKEUP</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x18</addressOffset>
        <description>Configuration n</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 0 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising-edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling-edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both-edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High-level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low-level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 0 Enable</description>
            <name>FILTEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 1 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 1 Enable</description>
            <name>FILTEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 2 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 2 Enable</description>
            <name>FILTEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 3 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 3 Enable</description>
            <name>FILTEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 4 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 4 Enable</description>
            <name>FILTEN4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x14</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 5 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x17</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 5 Enable</description>
            <name>FILTEN5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 6 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 6 Enable</description>
            <name>FILTEN6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 7 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 7 Enable</description>
            <name>FILTEN7</name>
          </field>
        </fields>
        <name>CONFIG0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x1C</addressOffset>
        <description>Configuration n</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 0 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising-edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling-edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both-edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High-level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low-level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 0 Enable</description>
            <name>FILTEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 1 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 1 Enable</description>
            <name>FILTEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 2 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 2 Enable</description>
            <name>FILTEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 3 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 3 Enable</description>
            <name>FILTEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 4 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 4 Enable</description>
            <name>FILTEN4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x14</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 5 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x17</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 5 Enable</description>
            <name>FILTEN5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 6 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 6 Enable</description>
            <name>FILTEN6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Input Sense 7 Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No detection</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Rising edge detection</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Falling edge detection</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Both edges detection</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High level detection</description>
                <name>HIGH</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low level detection</description>
                <name>LOW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SENSE7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Filter 7 Enable</description>
            <name>FILTEN7</name>
          </field>
        </fields>
        <name>CONFIG1</name>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x80</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42000400</baseAddress>
    <description>Event System Interface</description>
    <groupName>EVSYS</groupName>
    <interrupts>
      <interrupt>
        <name>EVSYS_INTREQ</name>
        <value>0x8</value>
      </interrupt>
    </interrupts>
    <name>EVSYS</name>
    <prependToName>EVSYS_</prependToName>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0x0</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Generic Clock Requests</description>
            <name>GCLKREQ</name>
          </field>
        </fields>
        <name>CTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Channel</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Channel Selection</description>
            <name>CHANNEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Event</description>
            <name>SWEVT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x7</bitWidth>
            <description>Event Generator Selection</description>
            <name>EVGEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Path Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Synchronous path</description>
                <name>SYNCHRONOUS</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Resynchronized path</description>
                <name>RESYNCHRONIZED</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Asynchronous path</description>
                <name>ASYNCHRONOUS</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PATH</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Edge Detection Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No event output when using the resynchronized or synchronous path</description>
                <name>NO_EVT_OUTPUT</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Event detection only on the rising edge of the signal from the event generator when using the resynchronized or synchronous path</description>
                <name>RISING_EDGE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Event detection only on the falling edge of the signal from the event generator when using the resynchronized or synchronous path</description>
                <name>FALLING_EDGE</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Event detection on rising and falling edges of the signal from the event generator when using the resynchronized or synchronous path</description>
                <name>BOTH_EDGES</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>EDGSEL</name>
          </field>
        </fields>
        <name>CHANNEL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>User Multiplexer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>User Multiplexer Selection</description>
            <name>USER</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Channel Event Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No Channel Output Selected</description>
                <name>0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CHANNEL</name>
          </field>
        </fields>
        <name>USER</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xC</addressOffset>
        <description>Channel Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 User Ready</description>
            <name>USRRDY0</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 User Ready</description>
            <name>USRRDY1</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 User Ready</description>
            <name>USRRDY2</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 User Ready</description>
            <name>USRRDY3</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 4 User Ready</description>
            <name>USRRDY4</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 5 User Ready</description>
            <name>USRRDY5</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 6 User Ready</description>
            <name>USRRDY6</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 7 User Ready</description>
            <name>USRRDY7</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Busy</description>
            <name>CHBUSY0</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Busy</description>
            <name>CHBUSY1</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Busy</description>
            <name>CHBUSY2</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Busy</description>
            <name>CHBUSY3</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 4 Busy</description>
            <name>CHBUSY4</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 5 Busy</description>
            <name>CHBUSY5</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 6 Busy</description>
            <name>CHBUSY6</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 7 Busy</description>
            <name>CHBUSY7</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 8 User Ready</description>
            <name>USRRDY8</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 9 User Ready</description>
            <name>USRRDY9</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 10 User Ready</description>
            <name>USRRDY10</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 11 User Ready</description>
            <name>USRRDY11</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 8 Busy</description>
            <name>CHBUSY8</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 9 Busy</description>
            <name>CHBUSY9</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 10 Busy</description>
            <name>CHBUSY10</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 11 Busy</description>
            <name>CHBUSY11</name>
          </field>
        </fields>
        <name>CHSTATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xF00FF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x10</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Overrun Interrupt Enable</description>
            <name>OVR0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Overrun Interrupt Enable</description>
            <name>OVR1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Overrun Interrupt Enable</description>
            <name>OVR2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Overrun Interrupt Enable</description>
            <name>OVR3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 4 Overrun Interrupt Enable</description>
            <name>OVR4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 5 Overrun Interrupt Enable</description>
            <name>OVR5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 6 Overrun Interrupt Enable</description>
            <name>OVR6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 7 Overrun Interrupt Enable</description>
            <name>OVR7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Event Detection Interrupt Enable</description>
            <name>EVD0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Event Detection Interrupt Enable</description>
            <name>EVD1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Event Detection Interrupt Enable</description>
            <name>EVD2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Event Detection Interrupt Enable</description>
            <name>EVD3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 4 Event Detection Interrupt Enable</description>
            <name>EVD4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 5 Event Detection Interrupt Enable</description>
            <name>EVD5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 6 Event Detection Interrupt Enable</description>
            <name>EVD6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 7 Event Detection Interrupt Enable</description>
            <name>EVD7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 8 Overrun Interrupt Enable</description>
            <name>OVR8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 9 Overrun Interrupt Enable</description>
            <name>OVR9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 10 Overrun Interrupt Enable</description>
            <name>OVR10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 11 Overrun Interrupt Enable</description>
            <name>OVR11</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 8 Event Detection Interrupt Enable</description>
            <name>EVD8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 9 Event Detection Interrupt Enable</description>
            <name>EVD9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 10 Event Detection Interrupt Enable</description>
            <name>EVD10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 11 Event Detection Interrupt Enable</description>
            <name>EVD11</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x14</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Overrun Interrupt Enable</description>
            <name>OVR0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Overrun Interrupt Enable</description>
            <name>OVR1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Overrun Interrupt Enable</description>
            <name>OVR2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Overrun Interrupt Enable</description>
            <name>OVR3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 4 Overrun Interrupt Enable</description>
            <name>OVR4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 5 Overrun Interrupt Enable</description>
            <name>OVR5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 6 Overrun Interrupt Enable</description>
            <name>OVR6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 7 Overrun Interrupt Enable</description>
            <name>OVR7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Event Detection Interrupt Enable</description>
            <name>EVD0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Event Detection Interrupt Enable</description>
            <name>EVD1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Event Detection Interrupt Enable</description>
            <name>EVD2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Event Detection Interrupt Enable</description>
            <name>EVD3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 4 Event Detection Interrupt Enable</description>
            <name>EVD4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 5 Event Detection Interrupt Enable</description>
            <name>EVD5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 6 Event Detection Interrupt Enable</description>
            <name>EVD6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 7 Event Detection Interrupt Enable</description>
            <name>EVD7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 8 Overrun Interrupt Enable</description>
            <name>OVR8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 9 Overrun Interrupt Enable</description>
            <name>OVR9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 10 Overrun Interrupt Enable</description>
            <name>OVR10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 11 Overrun Interrupt Enable</description>
            <name>OVR11</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 8 Event Detection Interrupt Enable</description>
            <name>EVD8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 9 Event Detection Interrupt Enable</description>
            <name>EVD9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 10 Event Detection Interrupt Enable</description>
            <name>EVD10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 11 Event Detection Interrupt Enable</description>
            <name>EVD11</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x18</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Overrun</description>
            <name>OVR0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Overrun</description>
            <name>OVR1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Overrun</description>
            <name>OVR2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Overrun</description>
            <name>OVR3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 4 Overrun</description>
            <name>OVR4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 5 Overrun</description>
            <name>OVR5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 6 Overrun</description>
            <name>OVR6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 7 Overrun</description>
            <name>OVR7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Event Detection</description>
            <name>EVD0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Event Detection</description>
            <name>EVD1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Event Detection</description>
            <name>EVD2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Event Detection</description>
            <name>EVD3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 4 Event Detection</description>
            <name>EVD4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 5 Event Detection</description>
            <name>EVD5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 6 Event Detection</description>
            <name>EVD6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 7 Event Detection</description>
            <name>EVD7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 8 Overrun</description>
            <name>OVR8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 9 Overrun</description>
            <name>OVR9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 10 Overrun</description>
            <name>OVR10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 11 Overrun</description>
            <name>OVR11</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 8 Event Detection</description>
            <name>EVD8</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 9 Event Detection</description>
            <name>EVD9</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 10 Event Detection</description>
            <name>EVD10</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 11 Event Detection</description>
            <name>EVD11</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x10</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x40000C00</baseAddress>
    <description>Generic Clock Generator</description>
    <groupName>GCLK</groupName>
    <interrupts></interrupts>
    <name>GCLK</name>
    <prependToName>GCLK_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <name>CTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x1</addressOffset>
        <description>Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Busy Status</description>
            <name>SYNCBUSY</name>
          </field>
        </fields>
        <name>STATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2</addressOffset>
        <description>Generic Clock Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Generic Clock Selection ID</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>DFLL48</description>
                <name>DFLL48</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>FDPLL</description>
                <name>FDPLL</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>FDPLL32K</description>
                <name>FDPLL32K</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>WDT</description>
                <name>WDT</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>RTC</description>
                <name>RTC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EIC</description>
                <name>EIC</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>USB</description>
                <name>USB</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_0</description>
                <name>EVSYS_0</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_1</description>
                <name>EVSYS_1</name>
                <value>0x8</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_2</description>
                <name>EVSYS_2</name>
                <value>0x9</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_3</description>
                <name>EVSYS_3</name>
                <value>0xA</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_4</description>
                <name>EVSYS_4</name>
                <value>0xB</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_5</description>
                <name>EVSYS_5</name>
                <value>0xC</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_6</description>
                <name>EVSYS_6</name>
                <value>0xD</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_7</description>
                <name>EVSYS_7</name>
                <value>0xE</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_8</description>
                <name>EVSYS_8</name>
                <value>0xF</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_9</description>
                <name>EVSYS_9</name>
                <value>0x10</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_10</description>
                <name>EVSYS_10</name>
                <value>0x11</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>EVSYS_11</description>
                <name>EVSYS_11</name>
                <value>0x12</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>SERCOMX_SLOW</description>
                <name>SERCOMX_SLOW</name>
                <value>0x13</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>SERCOM0_CORE</description>
                <name>SERCOM0_CORE</name>
                <value>0x14</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>SERCOM1_CORE</description>
                <name>SERCOM1_CORE</name>
                <value>0x15</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>SERCOM2_CORE</description>
                <name>SERCOM2_CORE</name>
                <value>0x16</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>SERCOM3_CORE</description>
                <name>SERCOM3_CORE</name>
                <value>0x17</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>SERCOM4_CORE</description>
                <name>SERCOM4_CORE</name>
                <value>0x18</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>SERCOM5_CORE</description>
                <name>SERCOM5_CORE</name>
                <value>0x19</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>TCC0_TCC1</description>
                <name>TCC0_TCC1</name>
                <value>0x1A</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>TCC2_TC3</description>
                <name>TCC2_TC3</name>
                <value>0x1B</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>TC4_TC5</description>
                <name>TC4_TC5</name>
                <value>0x1C</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>TC6_TC7</description>
                <name>TC6_TC7</name>
                <value>0x1D</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>ADC</description>
                <name>ADC</name>
                <value>0x1E</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>AC_DIG</description>
                <name>AC_DIG</name>
                <value>0x1F</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>AC_ANA</description>
                <name>AC_ANA</name>
                <value>0x20</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>DAC</description>
                <name>DAC</name>
                <value>0x21</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I2S_0</description>
                <name>I2S_0</name>
                <value>0x23</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>I2S_1</description>
                <name>I2S_1</name>
                <value>0x24</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>ID</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Generic Clock Generator</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Generic clock generator 0</description>
                <name>GCLK0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Generic clock generator 1</description>
                <name>GCLK1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Generic clock generator 2</description>
                <name>GCLK2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Generic clock generator 3</description>
                <name>GCLK3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Generic clock generator 4</description>
                <name>GCLK4</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Generic clock generator 5</description>
                <name>GCLK5</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Generic clock generator 6</description>
                <name>GCLK6</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Generic clock generator 7</description>
                <name>GCLK7</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>GEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Clock Enable</description>
            <name>CLKEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write Lock</description>
            <name>WRTLOCK</name>
          </field>
        </fields>
        <name>CLKCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Generic Clock Generator Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Generic Clock Generator Selection</description>
            <name>ID</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Source Select</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>XOSC oscillator output</description>
                <name>XOSC</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Generator input pad</description>
                <name>GCLKIN</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Generic clock generator 1 output</description>
                <name>GCLKGEN1</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>OSCULP32K oscillator output</description>
                <name>OSCULP32K</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>OSC32K oscillator output</description>
                <name>OSC32K</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>XOSC32K oscillator output</description>
                <name>XOSC32K</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>OSC8M oscillator output</description>
                <name>OSC8M</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>DFLL48M output</description>
                <name>DFLL48M</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>FDPLL output</description>
                <name>FDPLL</name>
                <value>0x8</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SRC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Generic Clock Generator Enable</description>
            <name>GENEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Improve Duty Cycle</description>
            <name>IDC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Off Value</description>
            <name>OOV</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Enable</description>
            <name>OE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x14</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Divide Selection</description>
            <name>DIVSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x15</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <name>GENCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>Generic Clock Generator Division</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Generic Clock Generator Selection</description>
            <name>ID</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Division Factor</description>
            <name>DIV</name>
          </field>
        </fields>
        <name>GENDIV</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.1.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x400</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x41007000</baseAddress>
    <description>HSB Matrix</description>
    <groupName>HMATRIXB</groupName>
    <interrupts></interrupts>
    <name>HMATRIX</name>
    <prependToName>HMATRIXB_</prependToName>
    <registers>
      <register>
        <addressOffset>0x80</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x88</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x90</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x98</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xA0</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xA8</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB0</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB8</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS7</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC0</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS8</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC8</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS9</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD0</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS10</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD8</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS11</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xE0</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS12</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xE8</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS13</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xF0</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS14</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xF8</addressOffset>
        <description>Priority A for Slave</description>
        <fields></fields>
        <name>PRAS15</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x84</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x8C</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x94</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x9C</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xA4</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xAC</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB4</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBC</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS7</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC4</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS8</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCC</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS9</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD4</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS10</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDC</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS11</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xE4</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS12</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xEC</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS13</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xF4</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS14</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xFC</addressOffset>
        <description>Priority B for Slave</description>
        <fields></fields>
        <name>PRBS15</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x110</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x114</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x118</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x11C</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x120</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x124</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x128</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x12C</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR7</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x130</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR8</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x134</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR9</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x138</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR10</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13C</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR11</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x140</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR12</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x144</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR13</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x148</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR14</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14C</addressOffset>
        <description>Special Function</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Special Function Register</description>
            <name>SFR</name>
          </field>
        </fields>
        <name>SFR15</name>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.1.2</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x1000</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x41006000</baseAddress>
    <description>Cortex-M0+ Micro-Trace Buffer</description>
    <groupName>MTB</groupName>
    <interrupts></interrupts>
    <name>MTB</name>
    <prependToName>MTB_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>MTB Position</description>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pointer Value Wraps</description>
            <name>WRAP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1D</bitWidth>
            <description>Trace Packet Location Pointer</description>
            <name>POINTER</name>
          </field>
        </fields>
        <name>POSITION</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>MTB Master</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Maximum Value of the Trace Buffer in SRAM</description>
            <name>MASK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Trace Start Input Enable</description>
            <name>TSTARTEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Trace Stop Input Enable</description>
            <name>TSTOPEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Special Function Register Write Privilege</description>
            <name>SFRWPRIV</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>SRAM Privilege</description>
            <name>RAMPRIV</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Halt Request</description>
            <name>HALTREQ</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Main Trace Enable</description>
            <name>EN</name>
          </field>
        </fields>
        <name>MASTER</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>MTB Flow</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Auto Stop Tracing</description>
            <name>AUTOSTOP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Auto Halt Request</description>
            <name>AUTOHALT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1D</bitWidth>
            <description>Watermark value</description>
            <name>WATERMARK</name>
          </field>
        </fields>
        <name>FLOW</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xC</addressOffset>
        <description>MTB Base</description>
        <fields></fields>
        <name>BASE</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xF00</addressOffset>
        <description>MTB Integration Mode Control</description>
        <fields></fields>
        <name>ITCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xFA0</addressOffset>
        <description>MTB Claim Set</description>
        <fields></fields>
        <name>CLAIMSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xFA4</addressOffset>
        <description>MTB Claim Clear</description>
        <fields></fields>
        <name>CLAIMCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xFB0</addressOffset>
        <description>MTB Lock Access</description>
        <fields></fields>
        <name>LOCKACCESS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFB4</addressOffset>
        <description>MTB Lock Status</description>
        <fields></fields>
        <name>LOCKSTATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFB8</addressOffset>
        <description>MTB Authentication Status</description>
        <fields></fields>
        <name>AUTHSTATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFBC</addressOffset>
        <description>MTB Device Architecture</description>
        <fields></fields>
        <name>DEVARCH</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFC8</addressOffset>
        <description>MTB Device Configuration</description>
        <fields></fields>
        <name>DEVID</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFCC</addressOffset>
        <description>MTB Device Type</description>
        <fields></fields>
        <name>DEVTYPE</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFD0</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>PID4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFD4</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>PID5</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFD8</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>PID6</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFDC</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>PID7</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFE0</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>PID0</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFE4</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>PID1</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFE8</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>PID2</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFEC</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>PID3</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFF0</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>CID0</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFF4</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>CID1</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFF8</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>CID2</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xFFC</addressOffset>
        <description>CoreSight</description>
        <fields></fields>
        <name>CID3</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x80</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x41004000</baseAddress>
    <description>Non-Volatile Memory Controller</description>
    <groupName>NVMCTRL</groupName>
    <interrupts>
      <interrupt>
        <name>NVMCTRL_INTREQ</name>
        <value>0x5</value>
      </interrupt>
    </interrupts>
    <name>NVMCTRL</name>
    <prependToName>NVMCTRL_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control A</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x7</bitWidth>
            <description>Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Erase Row - Erases the row addressed by the ADDR register.</description>
                <name>ER</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Write Page - Writes the contents of the page buffer to the page addressed by the ADDR register.</description>
                <name>WP</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Erase Auxiliary Row - Erases the auxiliary row addressed by the ADDR register. This command can be given only when the security bit is not set and only to the user configuration row.</description>
                <name>EAR</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Write Auxiliary Page - Writes the contents of the page buffer to the page addressed by the ADDR register. This command can be given only when the security bit is not set and only to the user configuration row.</description>
                <name>WAP</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Security Flow Command</description>
                <name>SF</name>
                <value>0xA</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Write lockbits</description>
                <name>WL</name>
                <value>0xF</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Lock Region - Locks the region containing the address location in the ADDR register.</description>
                <name>LR</name>
                <value>0x40</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Unlock Region - Unlocks the region containing the address location in the ADDR register.</description>
                <name>UR</name>
                <value>0x41</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Sets the power reduction mode.</description>
                <name>SPRM</name>
                <value>0x42</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clears the power reduction mode.</description>
                <name>CPRM</name>
                <value>0x43</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Page Buffer Clear - Clears the page buffer.</description>
                <name>PBC</name>
                <value>0x44</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Set Security Bit - Sets the security bit by writing 0x00 to the first byte in the lockbit row.</description>
                <name>SSB</name>
                <value>0x45</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Invalidates all cache lines.</description>
                <name>INVALL</name>
                <value>0x46</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CMD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Command Execution</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Execution Key</description>
                <name>KEY</name>
                <value>0xA5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CMDEX</name>
          </field>
        </fields>
        <name>CTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Control B</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>NVM Read Wait States</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Single Auto Wait State</description>
                <name>SINGLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Half Auto Wait State</description>
                <name>HALF</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual Auto Wait State</description>
                <name>DUAL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RWS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Manual Write</description>
            <name>MANW</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Power Reduction Mode during Sleep</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>NVM block enters low-power mode when entering sleep.NVM block exits low-power mode upon first access.</description>
                <name>WAKEONACCESS</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>NVM block enters low-power mode when entering sleep.NVM block exits low-power mode when exiting sleep.</description>
                <name>WAKEUPINSTANT</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Auto power reduction disabled.</description>
                <name>DISABLED</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SLEEPPRM</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>NVMCTRL Read Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>The NVM Controller (cache system) does not insert wait states on a cache miss. Gives the best system performance.</description>
                <name>NO_MISS_PENALTY</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Reduces power consumption of the cache system, but inserts a wait state each time there is a cache miss. This mode may not be relevant if CPU performance is required, as the application will be stalled and may lead to increase run time.</description>
                <name>LOW_POWER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>The cache system ensures that a cache hit or miss takes the same amount of time, determined by the number of programmed flash wait states. This mode can be used for real-time applications that require deterministic execution timings.</description>
                <name>DETERMINISTIC</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>READMODE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Cache Disable</description>
            <name>CACHEDIS</name>
          </field>
        </fields>
        <name>CTRLB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>NVM Parameter</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>NVM Pages</description>
            <name>NVMP</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Page Size</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>8 bytes</description>
                <name>8</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16 bytes</description>
                <name>16</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>32 bytes</description>
                <name>32</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>64 bytes</description>
                <name>64</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>128 bytes</description>
                <name>128</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>256 bytes</description>
                <name>256</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>512 bytes</description>
                <name>512</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>1024 bytes</description>
                <name>1024</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PSZ</name>
          </field>
        </fields>
        <name>PARAM</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xC</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>NVM Ready Interrupt Enable</description>
            <name>READY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error Interrupt Enable</description>
            <name>ERROR</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x10</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>NVM Ready Interrupt Enable</description>
            <name>READY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error Interrupt Enable</description>
            <name>ERROR</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x14</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>NVM Ready</description>
            <name>READY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error</description>
            <name>ERROR</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x18</addressOffset>
        <description>Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Power Reduction Mode</description>
            <name>PRM</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>NVM Page Buffer Active Loading</description>
            <name>LOAD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Programming Error Status</description>
            <name>PROGE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Lock Error Status</description>
            <name>LOCKE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>NVM Error</description>
            <name>NVME</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Security Bit Status</description>
            <name>SB</name>
          </field>
        </fields>
        <name>STATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1C</addressOffset>
        <description>Address</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x16</bitWidth>
            <description>NVM Address</description>
            <name>ADDR</name>
          </field>
        </fields>
        <name>ADDR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x20</addressOffset>
        <description>Lock Section</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Region Lock Bits</description>
            <name>LOCK</name>
          </field>
        </fields>
        <name>LOCK</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.6</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x8</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x40000000</baseAddress>
    <description>Peripheral Access Controller 0</description>
    <groupName>PAC</groupName>
    <interrupts></interrupts>
    <name>PAC0</name>
    <prependToName>PAC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Write Protection Clear</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1F</bitWidth>
            <description>Write Protection Clear</description>
            <name>WP</name>
          </field>
        </fields>
        <name>WPCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Write Protection Set</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1F</bitWidth>
            <description>Write Protection Set</description>
            <name>WP</name>
          </field>
        </fields>
        <name>WPSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x8</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x41000000</baseAddress>
    <derivedFrom>PAC0</derivedFrom>
    <description>Peripheral Access Controller 1</description>
    <groupName>PAC</groupName>
    <interrupts></interrupts>
    <name>PAC1</name>
    <prependToName>PAC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Write Protection Clear</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1F</bitWidth>
            <description>Write Protection Clear</description>
            <name>WP</name>
          </field>
        </fields>
        <name>WPCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Write Protection Set</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1F</bitWidth>
            <description>Write Protection Set</description>
            <name>WP</name>
          </field>
        </fields>
        <name>WPSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x8</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42000000</baseAddress>
    <derivedFrom>PAC0</derivedFrom>
    <description>Peripheral Access Controller 2</description>
    <groupName>PAC</groupName>
    <interrupts></interrupts>
    <name>PAC2</name>
    <prependToName>PAC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Write Protection Clear</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1F</bitWidth>
            <description>Write Protection Clear</description>
            <name>WP</name>
          </field>
        </fields>
        <name>WPCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Write Protection Set</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1F</bitWidth>
            <description>Write Protection Set</description>
            <name>WP</name>
          </field>
        </fields>
        <name>WPSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x80</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x40000400</baseAddress>
    <description>Power Manager</description>
    <groupName>PM</groupName>
    <interrupts>
      <interrupt>
        <name>PM_INTREQ</name>
        <value>0x0</value>
      </interrupt>
    </interrupts>
    <name>PM</name>
    <prependToName>PM_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control</description>
        <fields></fields>
        <name>CTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1</addressOffset>
        <description>Sleep Mode</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Idle Mode Configuration</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>The CPU clock domain is stopped</description>
                <name>CPU</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>The CPU and AHB clock domains are stopped</description>
                <name>AHB</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>The CPU, AHB and APB clock domains are stopped</description>
                <name>APB</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>IDLE</name>
          </field>
        </fields>
        <name>SLEEP</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>CPU Clock Select</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>CPU Prescaler Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 1</description>
                <name>DIV1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 2</description>
                <name>DIV2</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 4</description>
                <name>DIV4</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 8</description>
                <name>DIV8</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 16</description>
                <name>DIV16</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 32</description>
                <name>DIV32</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 64</description>
                <name>DIV64</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 128</description>
                <name>DIV128</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CPUDIV</name>
          </field>
        </fields>
        <name>CPUSEL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x9</addressOffset>
        <description>APBA Clock Select</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>APBA Prescaler Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 1</description>
                <name>DIV1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 2</description>
                <name>DIV2</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 4</description>
                <name>DIV4</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 8</description>
                <name>DIV8</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 16</description>
                <name>DIV16</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 32</description>
                <name>DIV32</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 64</description>
                <name>DIV64</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 128</description>
                <name>DIV128</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>APBADIV</name>
          </field>
        </fields>
        <name>APBASEL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xA</addressOffset>
        <description>APBB Clock Select</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>APBB Prescaler Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 1</description>
                <name>DIV1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 2</description>
                <name>DIV2</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 4</description>
                <name>DIV4</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 8</description>
                <name>DIV8</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 16</description>
                <name>DIV16</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 32</description>
                <name>DIV32</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 64</description>
                <name>DIV64</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 128</description>
                <name>DIV128</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>APBBDIV</name>
          </field>
        </fields>
        <name>APBBSEL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xB</addressOffset>
        <description>APBC Clock Select</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>APBC Prescaler Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 1</description>
                <name>DIV1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 2</description>
                <name>DIV2</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 4</description>
                <name>DIV4</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 8</description>
                <name>DIV8</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 16</description>
                <name>DIV16</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 32</description>
                <name>DIV32</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 64</description>
                <name>DIV64</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 128</description>
                <name>DIV128</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>APBCDIV</name>
          </field>
        </fields>
        <name>APBCSEL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x14</addressOffset>
        <description>AHB Mask</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>HPB0 AHB Clock Mask</description>
            <name>HPB0_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>HPB1 AHB Clock Mask</description>
            <name>HPB1_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>HPB2 AHB Clock Mask</description>
            <name>HPB2_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DSU AHB Clock Mask</description>
            <name>DSU_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>NVMCTRL AHB Clock Mask</description>
            <name>NVMCTRL_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DMAC AHB Clock Mask</description>
            <name>DMAC_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>USB AHB Clock Mask</description>
            <name>USB_</name>
          </field>
        </fields>
        <name>AHBMASK</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x7F</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x18</addressOffset>
        <description>APBA Mask</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>PAC0 APB Clock Enable</description>
            <name>PAC0_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>PM APB Clock Enable</description>
            <name>PM_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>SYSCTRL APB Clock Enable</description>
            <name>SYSCTRL_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>GCLK APB Clock Enable</description>
            <name>GCLK_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>WDT APB Clock Enable</description>
            <name>WDT_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>RTC APB Clock Enable</description>
            <name>RTC_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>EIC APB Clock Enable</description>
            <name>EIC_</name>
          </field>
        </fields>
        <name>APBAMASK</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x7F</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1C</addressOffset>
        <description>APBB Mask</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>PAC1 APB Clock Enable</description>
            <name>PAC1_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DSU APB Clock Enable</description>
            <name>DSU_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>NVMCTRL APB Clock Enable</description>
            <name>NVMCTRL_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>PORT APB Clock Enable</description>
            <name>PORT_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DMAC APB Clock Enable</description>
            <name>DMAC_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>USB APB Clock Enable</description>
            <name>USB_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>HMATRIX APB Clock Enable</description>
            <name>HMATRIX_</name>
          </field>
        </fields>
        <name>APBBMASK</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x7F</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x20</addressOffset>
        <description>APBC Mask</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>PAC2 APB Clock Enable</description>
            <name>PAC2_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>EVSYS APB Clock Enable</description>
            <name>EVSYS_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>SERCOM0 APB Clock Enable</description>
            <name>SERCOM0_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>SERCOM1 APB Clock Enable</description>
            <name>SERCOM1_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>SERCOM2 APB Clock Enable</description>
            <name>SERCOM2_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>SERCOM3 APB Clock Enable</description>
            <name>SERCOM3_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>SERCOM4 APB Clock Enable</description>
            <name>SERCOM4_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>SERCOM5 APB Clock Enable</description>
            <name>SERCOM5_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>TCC0 APB Clock Enable</description>
            <name>TCC0_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>TCC1 APB Clock Enable</description>
            <name>TCC1_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>TCC2 APB Clock Enable</description>
            <name>TCC2_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>TC3 APB Clock Enable</description>
            <name>TC3_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>TC4 APB Clock Enable</description>
            <name>TC4_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>TC5 APB Clock Enable</description>
            <name>TC5_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>TC6 APB Clock Enable</description>
            <name>TC6_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>TC7 APB Clock Enable</description>
            <name>TC7_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>ADC APB Clock Enable</description>
            <name>ADC_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>AC APB Clock Enable</description>
            <name>AC_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DAC APB Clock Enable</description>
            <name>DAC_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>PTC APB Clock Enable</description>
            <name>PTC_</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x15</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>RFCTRL APB Clock Enable</description>
            <name>RFCTRL_</name>
          </field>
        </fields>
        <name>APBCMASK</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x10000</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Clock Ready Interrupt Enable</description>
            <name>CKRDY</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x35</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Clock Ready Interrupt Enable</description>
            <name>CKRDY</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x36</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Clock Ready</description>
            <name>CKRDY</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x38</addressOffset>
        <description>Reset Cause</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Power On Reset</description>
            <name>POR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Brown Out 12 Detector Reset</description>
            <name>BOD12</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Brown Out 33 Detector Reset</description>
            <name>BOD33</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>External Reset</description>
            <name>EXT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Watchdog Reset</description>
            <name>WDT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>System Reset Request</description>
            <name>SYST</name>
          </field>
        </fields>
        <name>RCAUSE</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x1</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x200</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x41004400</baseAddress>
    <description>Port Module</description>
    <groupName>PORT</groupName>
    <interrupts></interrupts>
    <name>PORT</name>
    <prependToName>PORT_</prependToName>
    <registers>
      <register>
        <addressOffset>0x0</addressOffset>
        <description>Data Direction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <name>DIR0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x80</addressOffset>
        <description>Data Direction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <name>DIR1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x100</addressOffset>
        <description>Data Direction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <name>DIR2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4</addressOffset>
        <description>Data Direction Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Clear</description>
            <name>DIRCLR</name>
          </field>
        </fields>
        <name>DIRCLR0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x84</addressOffset>
        <description>Data Direction Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Clear</description>
            <name>DIRCLR</name>
          </field>
        </fields>
        <name>DIRCLR1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x104</addressOffset>
        <description>Data Direction Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Clear</description>
            <name>DIRCLR</name>
          </field>
        </fields>
        <name>DIRCLR2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x8</addressOffset>
        <description>Data Direction Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Set</description>
            <name>DIRSET</name>
          </field>
        </fields>
        <name>DIRSET0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x88</addressOffset>
        <description>Data Direction Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Set</description>
            <name>DIRSET</name>
          </field>
        </fields>
        <name>DIRSET1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x108</addressOffset>
        <description>Data Direction Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Set</description>
            <name>DIRSET</name>
          </field>
        </fields>
        <name>DIRSET2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC</addressOffset>
        <description>Data Direction Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Toggle</description>
            <name>DIRTGL</name>
          </field>
        </fields>
        <name>DIRTGL0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x8C</addressOffset>
        <description>Data Direction Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Toggle</description>
            <name>DIRTGL</name>
          </field>
        </fields>
        <name>DIRTGL1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x10C</addressOffset>
        <description>Data Direction Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Toggle</description>
            <name>DIRTGL</name>
          </field>
        </fields>
        <name>DIRTGL2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x10</addressOffset>
        <description>Data Output Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value</description>
            <name>OUT</name>
          </field>
        </fields>
        <name>OUT0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x90</addressOffset>
        <description>Data Output Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value</description>
            <name>OUT</name>
          </field>
        </fields>
        <name>OUT1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x110</addressOffset>
        <description>Data Output Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value</description>
            <name>OUT</name>
          </field>
        </fields>
        <name>OUT2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14</addressOffset>
        <description>Data Output Value Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Clear</description>
            <name>OUTCLR</name>
          </field>
        </fields>
        <name>OUTCLR0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x94</addressOffset>
        <description>Data Output Value Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Clear</description>
            <name>OUTCLR</name>
          </field>
        </fields>
        <name>OUTCLR1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x114</addressOffset>
        <description>Data Output Value Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Clear</description>
            <name>OUTCLR</name>
          </field>
        </fields>
        <name>OUTCLR2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x18</addressOffset>
        <description>Data Output Value Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Set</description>
            <name>OUTSET</name>
          </field>
        </fields>
        <name>OUTSET0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x98</addressOffset>
        <description>Data Output Value Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Set</description>
            <name>OUTSET</name>
          </field>
        </fields>
        <name>OUTSET1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x118</addressOffset>
        <description>Data Output Value Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Set</description>
            <name>OUTSET</name>
          </field>
        </fields>
        <name>OUTSET2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x1C</addressOffset>
        <description>Data Output Value Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Toggle</description>
            <name>OUTTGL</name>
          </field>
        </fields>
        <name>OUTTGL0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x9C</addressOffset>
        <description>Data Output Value Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Toggle</description>
            <name>OUTTGL</name>
          </field>
        </fields>
        <name>OUTTGL1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x11C</addressOffset>
        <description>Data Output Value Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Toggle</description>
            <name>OUTTGL</name>
          </field>
        </fields>
        <name>OUTTGL2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x20</addressOffset>
        <description>Data Input Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Input Value</description>
            <name>IN</name>
          </field>
        </fields>
        <name>IN0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xA0</addressOffset>
        <description>Data Input Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Input Value</description>
            <name>IN</name>
          </field>
        </fields>
        <name>IN1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x120</addressOffset>
        <description>Data Input Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Input Value</description>
            <name>IN</name>
          </field>
        </fields>
        <name>IN2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x24</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Input Sampling Mode</description>
            <name>SAMPLING</name>
          </field>
        </fields>
        <name>CTRL0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xA4</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Input Sampling Mode</description>
            <name>SAMPLING</name>
          </field>
        </fields>
        <name>CTRL1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x124</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Input Sampling Mode</description>
            <name>SAMPLING</name>
          </field>
        </fields>
        <name>CTRL2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0x28</addressOffset>
        <description>Write Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Pin Mask for Multiple Pin Configuration</description>
            <name>PINMASK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing</description>
            <name>PMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PMUX</description>
            <name>WRPMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1E</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PINCFG</description>
            <name>WRPINCFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Half-Word Select</description>
            <name>HWSEL</name>
          </field>
        </fields>
        <name>WRCONFIG0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0xA8</addressOffset>
        <description>Write Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Pin Mask for Multiple Pin Configuration</description>
            <name>PINMASK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing</description>
            <name>PMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PMUX</description>
            <name>WRPMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1E</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PINCFG</description>
            <name>WRPINCFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Half-Word Select</description>
            <name>HWSEL</name>
          </field>
        </fields>
        <name>WRCONFIG1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0x128</addressOffset>
        <description>Write Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Pin Mask for Multiple Pin Configuration</description>
            <name>PINMASK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing</description>
            <name>PMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PMUX</description>
            <name>WRPMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1E</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PINCFG</description>
            <name>WRPINCFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Half-Word Select</description>
            <name>HWSEL</name>
          </field>
        </fields>
        <name>WRCONFIG2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x30</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_0</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x31</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_1</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x32</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_2</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x33</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_3</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x34</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_4</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x35</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_5</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x36</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_6</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x37</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_7</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x38</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_8</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x39</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_9</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3A</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_10</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3B</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_11</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3C</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_12</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3D</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_13</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3E</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_14</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3F</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_15</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB0</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB1</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB2</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB3</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB4</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB5</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB6</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB7</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB8</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB9</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBA</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBB</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBC</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBD</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBE</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBF</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x130</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x131</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x132</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x133</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x134</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x135</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x136</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x137</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x138</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x139</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13A</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13B</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13C</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13D</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13E</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13F</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x40</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_0</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x41</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_1</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x42</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_2</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x43</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_3</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_4</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x45</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_5</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x46</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_6</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x47</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_7</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_8</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x49</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_9</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4A</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_10</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4B</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_11</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_12</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4D</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_13</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4E</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_14</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4F</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_15</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_16</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x51</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_17</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x52</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_18</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x53</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_19</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x54</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_20</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x55</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_21</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x56</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_22</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x57</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_23</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x58</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_24</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x59</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_25</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5A</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_26</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5B</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_27</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5C</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_28</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5D</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_29</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5E</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_30</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5F</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_31</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC0</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC1</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC2</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC3</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC4</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC5</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC6</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC7</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC8</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC9</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCA</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCB</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCC</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCD</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCE</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCF</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD0</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_16</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD1</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_17</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD2</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_18</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD3</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_19</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD4</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_20</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD5</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_21</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD6</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_22</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD7</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_23</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD8</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_24</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD9</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_25</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDA</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_26</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDB</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_27</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDC</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_28</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDD</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_29</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDE</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_30</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDF</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_31</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x140</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x141</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x142</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x143</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x144</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x145</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x146</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x147</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x148</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x149</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14A</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14B</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14C</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14D</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14E</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14F</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x150</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_16</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x151</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_17</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x152</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_18</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x153</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_19</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x154</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_20</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x155</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_21</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x156</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_22</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x157</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_23</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x158</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_24</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x159</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_25</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15A</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_26</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15B</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_27</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15C</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_28</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15D</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_29</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15E</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_30</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15F</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_31</name>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x200</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x60000000</baseAddress>
    <derivedFrom>PORT</derivedFrom>
    <description>Port Module (IOBUS)</description>
    <groupName>PORT_IOBUS</groupName>
    <interrupts></interrupts>
    <name>PORT_IOBUS</name>
    <prependToName>PORT_IOBUS_</prependToName>
    <registers>
      <register>
        <addressOffset>0x0</addressOffset>
        <description>Data Direction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <name>DIR0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x80</addressOffset>
        <description>Data Direction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <name>DIR1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x100</addressOffset>
        <description>Data Direction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <name>DIR2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4</addressOffset>
        <description>Data Direction Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Clear</description>
            <name>DIRCLR</name>
          </field>
        </fields>
        <name>DIRCLR0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x84</addressOffset>
        <description>Data Direction Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Clear</description>
            <name>DIRCLR</name>
          </field>
        </fields>
        <name>DIRCLR1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x104</addressOffset>
        <description>Data Direction Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Clear</description>
            <name>DIRCLR</name>
          </field>
        </fields>
        <name>DIRCLR2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x8</addressOffset>
        <description>Data Direction Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Set</description>
            <name>DIRSET</name>
          </field>
        </fields>
        <name>DIRSET0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x88</addressOffset>
        <description>Data Direction Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Set</description>
            <name>DIRSET</name>
          </field>
        </fields>
        <name>DIRSET1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x108</addressOffset>
        <description>Data Direction Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Set</description>
            <name>DIRSET</name>
          </field>
        </fields>
        <name>DIRSET2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC</addressOffset>
        <description>Data Direction Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Toggle</description>
            <name>DIRTGL</name>
          </field>
        </fields>
        <name>DIRTGL0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x8C</addressOffset>
        <description>Data Direction Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Toggle</description>
            <name>DIRTGL</name>
          </field>
        </fields>
        <name>DIRTGL1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x10C</addressOffset>
        <description>Data Direction Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Toggle</description>
            <name>DIRTGL</name>
          </field>
        </fields>
        <name>DIRTGL2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x10</addressOffset>
        <description>Data Output Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value</description>
            <name>OUT</name>
          </field>
        </fields>
        <name>OUT0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x90</addressOffset>
        <description>Data Output Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value</description>
            <name>OUT</name>
          </field>
        </fields>
        <name>OUT1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x110</addressOffset>
        <description>Data Output Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value</description>
            <name>OUT</name>
          </field>
        </fields>
        <name>OUT2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14</addressOffset>
        <description>Data Output Value Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Clear</description>
            <name>OUTCLR</name>
          </field>
        </fields>
        <name>OUTCLR0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x94</addressOffset>
        <description>Data Output Value Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Clear</description>
            <name>OUTCLR</name>
          </field>
        </fields>
        <name>OUTCLR1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x114</addressOffset>
        <description>Data Output Value Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Clear</description>
            <name>OUTCLR</name>
          </field>
        </fields>
        <name>OUTCLR2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x18</addressOffset>
        <description>Data Output Value Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Set</description>
            <name>OUTSET</name>
          </field>
        </fields>
        <name>OUTSET0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x98</addressOffset>
        <description>Data Output Value Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Set</description>
            <name>OUTSET</name>
          </field>
        </fields>
        <name>OUTSET1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x118</addressOffset>
        <description>Data Output Value Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Set</description>
            <name>OUTSET</name>
          </field>
        </fields>
        <name>OUTSET2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x1C</addressOffset>
        <description>Data Output Value Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Toggle</description>
            <name>OUTTGL</name>
          </field>
        </fields>
        <name>OUTTGL0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x9C</addressOffset>
        <description>Data Output Value Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Toggle</description>
            <name>OUTTGL</name>
          </field>
        </fields>
        <name>OUTTGL1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x11C</addressOffset>
        <description>Data Output Value Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Toggle</description>
            <name>OUTTGL</name>
          </field>
        </fields>
        <name>OUTTGL2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x20</addressOffset>
        <description>Data Input Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Input Value</description>
            <name>IN</name>
          </field>
        </fields>
        <name>IN0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xA0</addressOffset>
        <description>Data Input Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Input Value</description>
            <name>IN</name>
          </field>
        </fields>
        <name>IN1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x120</addressOffset>
        <description>Data Input Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Input Value</description>
            <name>IN</name>
          </field>
        </fields>
        <name>IN2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x24</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Input Sampling Mode</description>
            <name>SAMPLING</name>
          </field>
        </fields>
        <name>CTRL0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xA4</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Input Sampling Mode</description>
            <name>SAMPLING</name>
          </field>
        </fields>
        <name>CTRL1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x124</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Input Sampling Mode</description>
            <name>SAMPLING</name>
          </field>
        </fields>
        <name>CTRL2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0x28</addressOffset>
        <description>Write Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Pin Mask for Multiple Pin Configuration</description>
            <name>PINMASK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing</description>
            <name>PMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PMUX</description>
            <name>WRPMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1E</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PINCFG</description>
            <name>WRPINCFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Half-Word Select</description>
            <name>HWSEL</name>
          </field>
        </fields>
        <name>WRCONFIG0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0xA8</addressOffset>
        <description>Write Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Pin Mask for Multiple Pin Configuration</description>
            <name>PINMASK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing</description>
            <name>PMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PMUX</description>
            <name>WRPMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1E</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PINCFG</description>
            <name>WRPINCFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Half-Word Select</description>
            <name>HWSEL</name>
          </field>
        </fields>
        <name>WRCONFIG1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0x128</addressOffset>
        <description>Write Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Pin Mask for Multiple Pin Configuration</description>
            <name>PINMASK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing</description>
            <name>PMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PMUX</description>
            <name>WRPMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1E</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PINCFG</description>
            <name>WRPINCFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Half-Word Select</description>
            <name>HWSEL</name>
          </field>
        </fields>
        <name>WRCONFIG2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x30</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_0</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x31</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_1</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x32</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_2</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x33</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_3</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x34</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_4</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x35</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_5</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x36</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_6</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x37</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_7</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x38</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_8</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x39</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_9</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3A</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_10</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3B</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_11</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3C</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_12</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3D</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_13</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3E</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_14</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3F</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_15</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB0</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB1</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB2</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB3</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB4</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB5</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB6</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB7</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB8</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB9</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBA</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBB</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBC</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBD</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBE</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBF</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x130</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x131</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x132</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x133</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x134</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x135</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x136</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x137</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x138</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x139</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13A</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13B</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13C</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13D</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13E</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13F</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x40</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_0</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x41</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_1</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x42</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_2</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x43</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_3</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_4</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x45</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_5</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x46</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_6</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x47</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_7</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_8</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x49</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_9</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4A</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_10</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4B</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_11</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_12</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4D</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_13</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4E</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_14</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4F</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_15</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_16</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x51</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_17</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x52</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_18</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x53</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_19</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x54</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_20</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x55</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_21</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x56</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_22</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x57</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_23</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x58</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_24</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x59</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_25</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5A</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_26</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5B</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_27</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5C</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_28</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5D</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_29</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5E</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_30</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5F</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_31</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC0</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC1</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC2</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC3</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC4</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC5</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC6</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC7</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC8</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC9</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCA</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCB</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCC</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCD</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCE</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCF</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD0</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_16</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD1</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_17</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD2</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_18</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD3</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_19</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD4</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_20</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD5</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_21</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD6</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_22</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD7</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_23</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD8</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_24</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD9</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_25</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDA</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_26</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDB</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_27</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDC</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_28</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDD</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_29</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDE</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_30</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDF</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_31</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x140</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x141</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x142</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x143</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x144</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x145</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x146</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x147</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x148</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x149</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14A</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14B</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14C</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14D</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14E</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14F</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x150</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_16</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x151</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_17</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x152</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_18</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x153</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_19</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x154</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_20</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x155</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_21</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x156</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_22</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x157</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_23</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x158</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_24</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x159</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_25</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15A</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_26</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15B</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_27</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15C</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_28</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15D</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_29</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15E</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_30</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15F</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_31</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x0</addressOffset>
        <description>Data Direction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <name>DIR0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x80</addressOffset>
        <description>Data Direction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <name>DIR1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x100</addressOffset>
        <description>Data Direction</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <name>DIR2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4</addressOffset>
        <description>Data Direction Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Clear</description>
            <name>DIRCLR</name>
          </field>
        </fields>
        <name>DIRCLR0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x84</addressOffset>
        <description>Data Direction Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Clear</description>
            <name>DIRCLR</name>
          </field>
        </fields>
        <name>DIRCLR1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x104</addressOffset>
        <description>Data Direction Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Clear</description>
            <name>DIRCLR</name>
          </field>
        </fields>
        <name>DIRCLR2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x8</addressOffset>
        <description>Data Direction Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Set</description>
            <name>DIRSET</name>
          </field>
        </fields>
        <name>DIRSET0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x88</addressOffset>
        <description>Data Direction Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Set</description>
            <name>DIRSET</name>
          </field>
        </fields>
        <name>DIRSET1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x108</addressOffset>
        <description>Data Direction Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Set</description>
            <name>DIRSET</name>
          </field>
        </fields>
        <name>DIRSET2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC</addressOffset>
        <description>Data Direction Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Toggle</description>
            <name>DIRTGL</name>
          </field>
        </fields>
        <name>DIRTGL0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x8C</addressOffset>
        <description>Data Direction Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Toggle</description>
            <name>DIRTGL</name>
          </field>
        </fields>
        <name>DIRTGL1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x10C</addressOffset>
        <description>Data Direction Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Direction Toggle</description>
            <name>DIRTGL</name>
          </field>
        </fields>
        <name>DIRTGL2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x10</addressOffset>
        <description>Data Output Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value</description>
            <name>OUT</name>
          </field>
        </fields>
        <name>OUT0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x90</addressOffset>
        <description>Data Output Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value</description>
            <name>OUT</name>
          </field>
        </fields>
        <name>OUT1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x110</addressOffset>
        <description>Data Output Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value</description>
            <name>OUT</name>
          </field>
        </fields>
        <name>OUT2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14</addressOffset>
        <description>Data Output Value Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Clear</description>
            <name>OUTCLR</name>
          </field>
        </fields>
        <name>OUTCLR0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x94</addressOffset>
        <description>Data Output Value Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Clear</description>
            <name>OUTCLR</name>
          </field>
        </fields>
        <name>OUTCLR1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x114</addressOffset>
        <description>Data Output Value Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Clear</description>
            <name>OUTCLR</name>
          </field>
        </fields>
        <name>OUTCLR2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x18</addressOffset>
        <description>Data Output Value Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Set</description>
            <name>OUTSET</name>
          </field>
        </fields>
        <name>OUTSET0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x98</addressOffset>
        <description>Data Output Value Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Set</description>
            <name>OUTSET</name>
          </field>
        </fields>
        <name>OUTSET1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x118</addressOffset>
        <description>Data Output Value Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Set</description>
            <name>OUTSET</name>
          </field>
        </fields>
        <name>OUTSET2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x1C</addressOffset>
        <description>Data Output Value Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Toggle</description>
            <name>OUTTGL</name>
          </field>
        </fields>
        <name>OUTTGL0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x9C</addressOffset>
        <description>Data Output Value Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Toggle</description>
            <name>OUTTGL</name>
          </field>
        </fields>
        <name>OUTTGL1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x11C</addressOffset>
        <description>Data Output Value Toggle</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Output Value Toggle</description>
            <name>OUTTGL</name>
          </field>
        </fields>
        <name>OUTTGL2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x20</addressOffset>
        <description>Data Input Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Input Value</description>
            <name>IN</name>
          </field>
        </fields>
        <name>IN0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xA0</addressOffset>
        <description>Data Input Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Input Value</description>
            <name>IN</name>
          </field>
        </fields>
        <name>IN1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x120</addressOffset>
        <description>Data Input Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Port Data Input Value</description>
            <name>IN</name>
          </field>
        </fields>
        <name>IN2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x24</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Input Sampling Mode</description>
            <name>SAMPLING</name>
          </field>
        </fields>
        <name>CTRL0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xA4</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Input Sampling Mode</description>
            <name>SAMPLING</name>
          </field>
        </fields>
        <name>CTRL1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x124</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x20</bitWidth>
            <description>Input Sampling Mode</description>
            <name>SAMPLING</name>
          </field>
        </fields>
        <name>CTRL2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0x28</addressOffset>
        <description>Write Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Pin Mask for Multiple Pin Configuration</description>
            <name>PINMASK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing</description>
            <name>PMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PMUX</description>
            <name>WRPMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1E</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PINCFG</description>
            <name>WRPINCFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Half-Word Select</description>
            <name>HWSEL</name>
          </field>
        </fields>
        <name>WRCONFIG0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0xA8</addressOffset>
        <description>Write Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Pin Mask for Multiple Pin Configuration</description>
            <name>PINMASK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing</description>
            <name>PMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PMUX</description>
            <name>WRPMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1E</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PINCFG</description>
            <name>WRPINCFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Half-Word Select</description>
            <name>HWSEL</name>
          </field>
        </fields>
        <name>WRCONFIG1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0x128</addressOffset>
        <description>Write Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Pin Mask for Multiple Pin Configuration</description>
            <name>PINMASK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing</description>
            <name>PMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PMUX</description>
            <name>WRPMUX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1E</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write PINCFG</description>
            <name>WRPINCFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1F</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Half-Word Select</description>
            <name>HWSEL</name>
          </field>
        </fields>
        <name>WRCONFIG2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x30</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_0</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x31</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_1</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x32</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_2</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x33</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_3</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x34</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_4</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x35</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_5</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x36</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_6</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x37</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_7</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x38</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_8</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x39</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_9</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3A</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_10</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3B</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_11</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3C</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_12</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3D</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_13</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3E</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_14</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x3F</addressOffset>
        <description>Peripheral Multiplexing n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Even</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Peripheral Multiplexing Odd</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function A selected</description>
                <name>A</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function B selected</description>
                <name>B</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function C selected</description>
                <name>C</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function D selected</description>
                <name>D</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function E selected</description>
                <name>E</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function F selected</description>
                <name>F</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function G selected</description>
                <name>G</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Peripheral function H selected</description>
                <name>H</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PMUXO</name>
          </field>
        </fields>
        <name>PMUX0_15</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB0</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB1</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB2</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB3</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB4</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB5</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB6</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB7</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB8</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xB9</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBA</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBB</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBC</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBD</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBE</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xBF</addressOffset>
        <description>Peripheral Multiplexing n - Group 1</description>
        <fields></fields>
        <name>PMUX1_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x130</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x131</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x132</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x133</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x134</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x135</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x136</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x137</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x138</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x139</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13A</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13B</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13C</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13D</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13E</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x13F</addressOffset>
        <description>Peripheral Multiplexing n - Group 2</description>
        <fields></fields>
        <name>PMUX2_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x40</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_0</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x41</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_1</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x42</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_2</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x43</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_3</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_4</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x45</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_5</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x46</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_6</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x47</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_7</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_8</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x49</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_9</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4A</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_10</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4B</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_11</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_12</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4D</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_13</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4E</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_14</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4F</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_15</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_16</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x51</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_17</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x52</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_18</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x53</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_19</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x54</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_20</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x55</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_21</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x56</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_22</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x57</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_23</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x58</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_24</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x59</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_25</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5A</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_26</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5B</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_27</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5C</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_28</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5D</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_29</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5E</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_30</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x5F</addressOffset>
        <description>Pin Configuration n - Group 0</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Peripheral Multiplexer Enable</description>
            <name>PMUXEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Input Enable</description>
            <name>INEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pull Enable</description>
            <name>PULLEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Driver Strength Selection</description>
            <name>DRVSTR</name>
          </field>
        </fields>
        <name>PINCFG0_31</name>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC0</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC1</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC2</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC3</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC4</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC5</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC6</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC7</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC8</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xC9</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCA</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCB</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCC</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCD</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCE</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xCF</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD0</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_16</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD1</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_17</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD2</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_18</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD3</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_19</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD4</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_20</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD5</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_21</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD6</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_22</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD7</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_23</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD8</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_24</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xD9</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_25</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDA</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_26</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDB</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_27</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDC</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_28</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDD</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_29</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDE</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_30</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0xDF</addressOffset>
        <description>Pin Configuration n - Group 1</description>
        <fields></fields>
        <name>PINCFG1_31</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x140</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_0</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x141</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_1</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x142</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_2</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x143</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_3</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x144</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_4</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x145</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_5</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x146</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_6</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x147</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_7</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x148</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_8</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x149</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_9</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14A</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_10</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14B</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_11</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14C</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_12</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14D</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_13</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14E</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_14</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x14F</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_15</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x150</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_16</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x151</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_17</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x152</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_18</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x153</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_19</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x154</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_20</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x155</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_21</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x156</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_22</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x157</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_23</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x158</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_24</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x159</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_25</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15A</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_26</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15B</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_27</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15C</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_28</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15D</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_29</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15E</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_30</name>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x15F</addressOffset>
        <description>Pin Configuration n - Group 2</description>
        <fields></fields>
        <name>PINCFG2_31</name>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x8</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42005400</baseAddress>
    <description>RF233 control module</description>
    <groupName>RFCTRL</groupName>
    <interrupts></interrupts>
    <name>RFCTRL</name>
    <prependToName>RFCTRL_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Front-end control bus configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Front-end control signal 0 configuration</description>
            <name>F0CFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Front-end control signal 1 configuration</description>
            <name>F1CFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Front-end control signal 2 configuration</description>
            <name>F2CFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Front-end control signal 3 configuration</description>
            <name>F3CFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Front-end control signal 4 configuration</description>
            <name>F4CFG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Front-end control signal 5 configuration</description>
            <name>F5CFG</name>
          </field>
        </fields>
        <name>FECFG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x40001400</baseAddress>
    <description>Real-Time Counter</description>
    <groupName>RTC</groupName>
    <interrupts>
      <interrupt>
        <name>RTC_INTREQ</name>
        <value>0x3</value>
      </interrupt>
    </interrupts>
    <name>RTC</name>
    <prependToName>RTC_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42000800</baseAddress>
    <description>Serial Communication Interface 0</description>
    <groupName>SERCOM</groupName>
    <interrupts>
      <interrupt>
        <name>SERCOM0_INTREQ</name>
        <value>0x9</value>
      </interrupt>
    </interrupts>
    <name>SERCOM0</name>
    <prependToName>SERCOM_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42000C00</baseAddress>
    <derivedFrom>SERCOM0</derivedFrom>
    <description>Serial Communication Interface 1</description>
    <groupName>SERCOM</groupName>
    <interrupts>
      <interrupt>
        <name>SERCOM1_INTREQ</name>
        <value>0xA</value>
      </interrupt>
    </interrupts>
    <name>SERCOM1</name>
    <prependToName>SERCOM_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42001000</baseAddress>
    <derivedFrom>SERCOM0</derivedFrom>
    <description>Serial Communication Interface 2</description>
    <groupName>SERCOM</groupName>
    <interrupts>
      <interrupt>
        <name>SERCOM2_INTREQ</name>
        <value>0xB</value>
      </interrupt>
    </interrupts>
    <name>SERCOM2</name>
    <prependToName>SERCOM_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42001400</baseAddress>
    <derivedFrom>SERCOM0</derivedFrom>
    <description>Serial Communication Interface 3</description>
    <groupName>SERCOM</groupName>
    <interrupts>
      <interrupt>
        <name>SERCOM3_INTREQ</name>
        <value>0xC</value>
      </interrupt>
    </interrupts>
    <name>SERCOM3</name>
    <prependToName>SERCOM_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42001800</baseAddress>
    <derivedFrom>SERCOM0</derivedFrom>
    <description>Serial Communication Interface 4</description>
    <groupName>SERCOM</groupName>
    <interrupts>
      <interrupt>
        <name>SERCOM4_INTREQ</name>
        <value>0xD</value>
      </interrupt>
    </interrupts>
    <name>SERCOM4</name>
    <prependToName>SERCOM_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42001C00</baseAddress>
    <derivedFrom>SERCOM0</derivedFrom>
    <description>Serial Communication Interface 5</description>
    <groupName>SERCOM</groupName>
    <interrupts>
      <interrupt>
        <name>SERCOM5_INTREQ</name>
        <value>0xE</value>
      </interrupt>
    </interrupts>
    <name>SERCOM5</name>
    <prependToName>SERCOM_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.0.0</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x80</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x40000800</baseAddress>
    <description>System Control</description>
    <groupName>SYSCTRL</groupName>
    <interrupts>
      <interrupt>
        <name>SYSCTRL_INTREQ</name>
        <value>0x1</value>
      </interrupt>
    </interrupts>
    <name>SYSCTRL</name>
    <prependToName>SYSCTRL_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>XOSC Ready Interrupt Enable</description>
            <name>XOSCRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>XOSC32K Ready Interrupt Enable</description>
            <name>XOSC32KRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>OSC32K Ready Interrupt Enable</description>
            <name>OSC32KRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>OSC8M Ready Interrupt Enable</description>
            <name>OSC8MRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Ready Interrupt Enable</description>
            <name>DFLLRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Out Of Bounds Interrupt Enable</description>
            <name>DFLLOOB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Lock Fine Interrupt Enable</description>
            <name>DFLLLCKF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Lock Coarse Interrupt Enable</description>
            <name>DFLLLCKC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Reference Clock Stopped Interrupt Enable</description>
            <name>DFLLRCS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Ready Interrupt Enable</description>
            <name>BOD33RDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Detection Interrupt Enable</description>
            <name>BOD33DET</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Synchronization Ready Interrupt Enable</description>
            <name>B33SRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Rise Interrupt Enable</description>
            <name>DPLLLCKR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Fall Interrupt Enable</description>
            <name>DPLLLCKF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Timeout Interrupt Enable</description>
            <name>DPLLLTO</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>XOSC Ready Interrupt Enable</description>
            <name>XOSCRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>XOSC32K Ready Interrupt Enable</description>
            <name>XOSC32KRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>OSC32K Ready Interrupt Enable</description>
            <name>OSC32KRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>OSC8M Ready Interrupt Enable</description>
            <name>OSC8MRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Ready Interrupt Enable</description>
            <name>DFLLRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Out Of Bounds Interrupt Enable</description>
            <name>DFLLOOB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Lock Fine Interrupt Enable</description>
            <name>DFLLLCKF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Lock Coarse Interrupt Enable</description>
            <name>DFLLLCKC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Reference Clock Stopped Interrupt Enable</description>
            <name>DFLLRCS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Ready Interrupt Enable</description>
            <name>BOD33RDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Detection Interrupt Enable</description>
            <name>BOD33DET</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Synchronization Ready Interrupt Enable</description>
            <name>B33SRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Rise Interrupt Enable</description>
            <name>DPLLLCKR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Fall Interrupt Enable</description>
            <name>DPLLLCKF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Timeout Interrupt Enable</description>
            <name>DPLLLTO</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x8</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>XOSC Ready</description>
            <name>XOSCRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>XOSC32K Ready</description>
            <name>XOSC32KRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>OSC32K Ready</description>
            <name>OSC32KRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>OSC8M Ready</description>
            <name>OSC8MRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Ready</description>
            <name>DFLLRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Out Of Bounds</description>
            <name>DFLLOOB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Lock Fine</description>
            <name>DFLLLCKF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Lock Coarse</description>
            <name>DFLLLCKC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Reference Clock Stopped</description>
            <name>DFLLRCS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Ready</description>
            <name>BOD33RDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Detection</description>
            <name>BOD33DET</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Synchronization Ready</description>
            <name>B33SRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Rise</description>
            <name>DPLLLCKR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Fall</description>
            <name>DPLLLCKF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Timeout</description>
            <name>DPLLLTO</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0xC</addressOffset>
        <description>Power and Clocks Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>XOSC Ready</description>
            <name>XOSCRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>XOSC32K Ready</description>
            <name>XOSC32KRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>OSC32K Ready</description>
            <name>OSC32KRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>OSC8M Ready</description>
            <name>OSC8MRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Ready</description>
            <name>DFLLRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Out Of Bounds</description>
            <name>DFLLOOB</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Lock Fine</description>
            <name>DFLLLCKF</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Lock Coarse</description>
            <name>DFLLLCKC</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Reference Clock Stopped</description>
            <name>DFLLRCS</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Ready</description>
            <name>BOD33RDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Detection</description>
            <name>BOD33DET</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>BOD33 Synchronization Ready</description>
            <name>B33SRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Rise</description>
            <name>DPLLLCKR</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Fall</description>
            <name>DPLLLCKF</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Timeout</description>
            <name>DPLLLTO</name>
          </field>
        </fields>
        <name>PCLKSR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x10</addressOffset>
        <description>External Multipurpose Crystal Oscillator (XOSC) Control</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Oscillator Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Crystal Oscillator Enable</description>
            <name>XTALEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>On Demand Control</description>
            <name>ONDEMAND</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Oscillator Gain</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>2MHz</description>
                <name>0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>4MHz</description>
                <name>1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>8MHz</description>
                <name>2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16MHz</description>
                <name>3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>30MHz</description>
                <name>4</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>GAIN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Automatic Amplitude Gain Control</description>
            <name>AMPGC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Start-Up Time</description>
            <name>STARTUP</name>
          </field>
        </fields>
        <name>XOSC</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x80</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x14</addressOffset>
        <description>32kHz External Crystal Oscillator (XOSC32K) Control</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Oscillator Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Crystal Oscillator Enable</description>
            <name>XTALEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>32kHz Output Enable</description>
            <name>EN32K</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>1kHz Output Enable</description>
            <name>EN1K</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Automatic Amplitude Control Enable</description>
            <name>AAMPEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>On Demand Control</description>
            <name>ONDEMAND</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Oscillator Start-Up Time</description>
            <name>STARTUP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write Lock</description>
            <name>WRTLOCK</name>
          </field>
        </fields>
        <name>XOSC32K</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x80</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x18</addressOffset>
        <description>32kHz Internal Oscillator (OSC32K) Control</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Oscillator Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>32kHz Output Enable</description>
            <name>EN32K</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>1kHz Output Enable</description>
            <name>EN1K</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>On Demand Control</description>
            <name>ONDEMAND</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Oscillator Start-Up Time</description>
            <name>STARTUP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write Lock</description>
            <name>WRTLOCK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x7</bitWidth>
            <description>Oscillator Calibration</description>
            <name>CALIB</name>
          </field>
        </fields>
        <name>OSC32K</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x3F0080</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1C</addressOffset>
        <description>32kHz Ultra Low Power Internal Oscillator (OSCULP32K) Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Oscillator Calibration</description>
            <name>CALIB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Write Lock</description>
            <name>WRTLOCK</name>
          </field>
        </fields>
        <name>OSCULP32K</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x1F</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x20</addressOffset>
        <description>8MHz Internal Oscillator (OSC8M) Control</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Oscillator Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>On Demand Control</description>
            <name>ONDEMAND</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Oscillator Prescaler</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>1</description>
                <name>0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>2</description>
                <name>1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>4</description>
                <name>2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>8</description>
                <name>3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PRESC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0xC</bitWidth>
            <description>Oscillator Calibration</description>
            <name>CALIB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1E</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Oscillator Frequency Range</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>4 to 6MHz</description>
                <name>0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>6 to 8MHz</description>
                <name>1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>8 to 11MHz</description>
                <name>2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>11 to 15MHz</description>
                <name>3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>FRANGE</name>
          </field>
        </fields>
        <name>OSC8M</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x87070382</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x24</addressOffset>
        <description>DFLL48M Control</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DFLL Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Operating Mode Selection</description>
            <name>MODE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Stable DFLL Frequency</description>
            <name>STABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Lose Lock After Wake</description>
            <name>LLAW</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>USB Clock Recovery Mode</description>
            <name>USBCRM</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>On Demand Control</description>
            <name>ONDEMAND</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Chill Cycle Disable</description>
            <name>CCDIS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Quick Lock Disable</description>
            <name>QLDIS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Bypass Coarse Lock</description>
            <name>BPLCKC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wait Lock</description>
            <name>WAITLOCK</name>
          </field>
        </fields>
        <name>DFLLCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x80</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x28</addressOffset>
        <description>DFLL48M Value</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0xA</bitWidth>
            <description>Fine Value</description>
            <name>FINE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Coarse Value</description>
            <name>COARSE</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>Multiplication Ratio Difference</description>
            <name>DIFF</name>
          </field>
        </fields>
        <name>DFLLVAL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2C</addressOffset>
        <description>DFLL48M Multiplier</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x10</bitWidth>
            <description>DFLL Multiply Factor</description>
            <name>MUL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0xA</bitWidth>
            <description>Fine Maximum Step</description>
            <name>FSTEP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Coarse Maximum Step</description>
            <name>CSTEP</name>
          </field>
        </fields>
        <name>DFLLMUL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x30</addressOffset>
        <description>DFLL48M Synchronization</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Read Request</description>
            <name>READREQ</name>
          </field>
        </fields>
        <name>DFLLSYNC</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>3.3V Brown-Out Detector (BOD33) Control</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Hysteresis</description>
            <name>HYST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>BOD33 Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No action</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>The BOD33 generates a reset</description>
                <name>RESET</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>The BOD33 generates an interrupt</description>
                <name>INTERRUPT</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>ACTION</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Operation Mode</description>
            <name>MODE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Clock Enable</description>
            <name>CEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Prescaler Select</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 2</description>
                <name>DIV2</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 4</description>
                <name>DIV4</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 8</description>
                <name>DIV8</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 16</description>
                <name>DIV16</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 32</description>
                <name>DIV32</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 64</description>
                <name>DIV64</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 128</description>
                <name>DIV128</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 256</description>
                <name>DIV256</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 512</description>
                <name>DIV512</name>
                <value>0x8</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 1024</description>
                <name>DIV1K</name>
                <value>0x9</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 2048</description>
                <name>DIV2K</name>
                <value>0xA</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 4096</description>
                <name>DIV4K</name>
                <value>0xB</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 8192</description>
                <name>DIV8K</name>
                <value>0xC</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 16384</description>
                <name>DIV16K</name>
                <value>0xD</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 32768</description>
                <name>DIV32K</name>
                <value>0xE</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide clock by 65536</description>
                <name>DIV64K</name>
                <value>0xF</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>BOD33 Threshold Level</description>
            <name>LEVEL</name>
          </field>
        </fields>
        <name>BOD33</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x3C</addressOffset>
        <description>Voltage Regulator System (VREG) Control</description>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Force LDO Voltage Regulator</description>
            <name>FORCELDO</name>
          </field>
        </fields>
        <name>VREG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Voltage References System (VREF) Control</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Temperature Sensor Enable</description>
            <name>TSEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Bandgap Output Enable</description>
            <name>BGOUTEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0xB</bitWidth>
            <description>Bandgap Voltage Generator Calibration</description>
            <name>CALIB</name>
          </field>
        </fields>
        <name>VREF</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x44</addressOffset>
        <description>DPLL Control A</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>On Demand Clock Activation</description>
            <name>ONDEMAND</name>
          </field>
        </fields>
        <name>DPLLCTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x80</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x48</addressOffset>
        <description>DPLL Ratio Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0xC</bitWidth>
            <description>Loop Divider Ratio</description>
            <name>LDR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Loop Divider Ratio Fractional Part</description>
            <name>LDRFRAC</name>
          </field>
        </fields>
        <name>DPLLRATIO</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4C</addressOffset>
        <description>DPLL Control B</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Proportional Integral Filter Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Default filter mode</description>
                <name>DEFAULT</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Low bandwidth filter</description>
                <name>LBFILT</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High bandwidth filter</description>
                <name>HBFILT</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>High damping filter</description>
                <name>HDFILT</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>FILTER</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Low-Power Enable</description>
            <name>LPEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wake Up Fast</description>
            <name>WUF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Reference Clock Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>CLK_DPLL_REF0 clock reference</description>
                <name>REF0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>CLK_DPLL_REF1 clock reference</description>
                <name>REF1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>GCLK_DPLL clock reference</description>
                <name>GCLK</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>REFCLK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Lock Time</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No time-out</description>
                <name>DEFAULT</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Time-out if no lock within 8 ms</description>
                <name>8MS</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Time-out if no lock within 9 ms</description>
                <name>9MS</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Time-out if no lock within 10 ms</description>
                <name>10MS</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Time-out if no lock within 11 ms</description>
                <name>11MS</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>LTIME</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Lock Bypass</description>
            <name>LBYPASS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0xB</bitWidth>
            <description>Clock Divider</description>
            <name>DIV</name>
          </field>
        </fields>
        <name>DPLLCTRLB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x50</addressOffset>
        <description>DPLL Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Lock Status</description>
            <name>LOCK</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Clock Ready</description>
            <name>CLKRDY</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>DPLL Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Divider Enable</description>
            <name>DIV</name>
          </field>
        </fields>
        <name>DPLLSTATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42002C00</baseAddress>
    <description>Basic Timer Counter 3</description>
    <groupName>TC</groupName>
    <interrupts>
      <interrupt>
        <name>TC3_INTREQ</name>
        <value>0x12</value>
      </interrupt>
    </interrupts>
    <name>TC3</name>
    <prependToName>TC_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.2.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42003000</baseAddress>
    <derivedFrom>TC3</derivedFrom>
    <description>Basic Timer Counter 4</description>
    <groupName>TC</groupName>
    <interrupts>
      <interrupt>
        <name>TC4_INTREQ</name>
        <value>0x13</value>
      </interrupt>
    </interrupts>
    <name>TC4</name>
    <prependToName>TC_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.2.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42003400</baseAddress>
    <derivedFrom>TC3</derivedFrom>
    <description>Basic Timer Counter 5</description>
    <groupName>TC</groupName>
    <interrupts>
      <interrupt>
        <name>TC5_INTREQ</name>
        <value>0x14</value>
      </interrupt>
    </interrupts>
    <name>TC5</name>
    <prependToName>TC_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.2.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42003800</baseAddress>
    <derivedFrom>TC3</derivedFrom>
    <description>Basic Timer Counter 6</description>
    <groupName>TC</groupName>
    <interrupts>
      <interrupt>
        <name>TC6_INTREQ</name>
        <value>0x15</value>
      </interrupt>
    </interrupts>
    <name>TC6</name>
    <prependToName>TC_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.2.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x40</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42003C00</baseAddress>
    <derivedFrom>TC3</derivedFrom>
    <description>Basic Timer Counter 7</description>
    <groupName>TC</groupName>
    <interrupts>
      <interrupt>
        <name>TC7_INTREQ</name>
        <value>0x16</value>
      </interrupt>
    </interrupts>
    <name>TC7</name>
    <prependToName>TC_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.2.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x90</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42002000</baseAddress>
    <description>Timer Counter Control 0</description>
    <groupName>TCC</groupName>
    <interrupts>
      <interrupt>
        <name>TCC0_INTREQ</name>
        <value>0xF</value>
      </interrupt>
    </interrupts>
    <name>TCC0</name>
    <prependToName>TCC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control A</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Enhanced Resolution</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is disabled</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is done every 16 PWM frames</description>
                <name>DITH4</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is done every 32 PWM frames</description>
                <name>DITH5</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is done every 64 PWM frames</description>
                <name>DITH6</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RESOLUTION</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Prescaler</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No division</description>
                <name>DIV1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 2</description>
                <name>DIV2</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 4</description>
                <name>DIV4</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 8</description>
                <name>DIV8</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 16</description>
                <name>DIV16</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 64</description>
                <name>DIV64</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 256</description>
                <name>DIV256</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 1024</description>
                <name>DIV1024</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PRESCALER</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Prescaler and Counter Synchronization Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Reload or reset counter on next GCLK</description>
                <name>GCLK</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Reload or reset counter on next prescaler clock</description>
                <name>PRESC</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Reload or reset counter on next GCLK and reset prescaler counter</description>
                <name>RESYNC</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PRESCSYNC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Auto Lock</description>
            <name>ALOCK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 0 Enable</description>
            <name>CPTEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 1 Enable</description>
            <name>CPTEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 2 Enable</description>
            <name>CPTEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 3 Enable</description>
            <name>CPTEN3</name>
          </field>
        </fields>
        <name>CTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Control B Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Lock Update</description>
            <name>LUPD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>One-Shot</description>
            <name>ONESHOT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Index Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Command disabled: Index toggles between cycles A and B</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Set index: cycle B will be forced in the next cycle</description>
                <name>SET</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear index: cycle A will be forced in the next cycle</description>
                <name>CLEAR</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hold index: the next cycle will be the same as the current cycle</description>
                <name>HOLD</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>IDXCMD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>TCC Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No action</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear start, restart or retrigger</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force stop</description>
                <name>STOP</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force update of double buffered registers</description>
                <name>UPDATE</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force COUNT read synchronization</description>
                <name>READSYNC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CMD</name>
          </field>
        </fields>
        <name>CTRLBCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x5</addressOffset>
        <description>Control B Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Lock Update</description>
            <name>LUPD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>One-Shot</description>
            <name>ONESHOT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Index Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Command disabled: Index toggles between cycles A and B</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Set index: cycle B will be forced in the next cycle</description>
                <name>SET</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear index: cycle A will be forced in the next cycle</description>
                <name>CLEAR</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hold index: the next cycle will be the same as the current cycle</description>
                <name>HOLD</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>IDXCMD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>TCC Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No action</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear start, restart or retrigger</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force stop</description>
                <name>STOP</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force update of double buffered registers</description>
                <name>UPDATE</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force COUNT read synchronization</description>
                <name>READSYNC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CMD</name>
          </field>
        </fields>
        <name>CTRLBSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x8</addressOffset>
        <description>Synchronization Busy</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swrst Busy</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable Busy</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Ctrlb Busy</description>
            <name>CTRLB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Status Busy</description>
            <name>STATUS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Count Busy</description>
            <name>COUNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Busy</description>
            <name>PATT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wave Busy</description>
            <name>WAVE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Period busy</description>
            <name>PER</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 0 Busy</description>
            <name>CC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 1 Busy</description>
            <name>CC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 2 Busy</description>
            <name>CC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 3 Busy</description>
            <name>CC3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Buffer Busy</description>
            <name>PATTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wave Buffer Busy</description>
            <name>WAVEB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Period Buffer Busy</description>
            <name>PERB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 0 Busy</description>
            <name>CCB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x14</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 1 Busy</description>
            <name>CCB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x15</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 2 Busy</description>
            <name>CCB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 3 Busy</description>
            <name>CCB3</name>
          </field>
        </fields>
        <name>SYNCBUSY</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xC</addressOffset>
        <description>Recoverable Fault A Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Source</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Fault input disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>MCEx (x=0,1) event input</description>
                <name>ENABLE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Inverted MCEx (x=0,1) event input</description>
                <name>INVERT</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternate fault (A or B) state at the end of the previous period</description>
                <name>ALTFAULT</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SRC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault A Keeper</description>
            <name>KEEP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault A Qualification</description>
            <name>QUAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Blanking Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No blanking applied</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from rising edge of the output waveform</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from falling edge of the output waveform</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from each toggle of the output waveform</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>BLANK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault A Restart</description>
            <name>RESTART</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Halt Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Halt action disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hardware halt action</description>
                <name>HW</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Software halt action</description>
                <name>SW</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>NR</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>HALT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Capture Channel</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 0</description>
                <name>CC0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 1</description>
                <name>CC1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 2</description>
                <name>CC2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 3</description>
                <name>CC3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CHSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Fault A Capture Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No capture</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture on fault</description>
                <name>CAPT</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum capture</description>
                <name>CAPTMIN</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum capture</description>
                <name>CAPTMAX</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum local detection</description>
                <name>LOCMIN</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum local detection</description>
                <name>LOCMAX</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum and maximum local detection</description>
                <name>DERIV0</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CAPTURE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Fault A Blanking Time</description>
            <name>BLANKVAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Fault A Filter Value</description>
            <name>FILTERVAL</name>
          </field>
        </fields>
        <name>FCTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x10</addressOffset>
        <description>Recoverable Fault B Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Source</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Fault input disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>MCEx (x=0,1) event input</description>
                <name>ENABLE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Inverted MCEx (x=0,1) event input</description>
                <name>INVERT</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternate fault (A or B) state at the end of the previous period</description>
                <name>ALTFAULT</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SRC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault B Keeper</description>
            <name>KEEP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault B Qualification</description>
            <name>QUAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Blanking Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No blanking applied</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from rising edge of the output waveform</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from falling edge of the output waveform</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from each toggle of the output waveform</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>BLANK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault B Restart</description>
            <name>RESTART</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Halt Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Halt action disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hardware halt action</description>
                <name>HW</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Software halt action</description>
                <name>SW</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>NR</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>HALT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Capture Channel</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 0</description>
                <name>CC0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 1</description>
                <name>CC1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 2</description>
                <name>CC2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 3</description>
                <name>CC3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CHSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Fault B Capture Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No capture</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture on fault</description>
                <name>CAPT</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum capture</description>
                <name>CAPTMIN</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum capture</description>
                <name>CAPTMAX</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum local detection</description>
                <name>LOCMIN</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum local detection</description>
                <name>LOCMAX</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum and maximum local detection</description>
                <name>DERIV0</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CAPTURE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Fault B Blanking Time</description>
            <name>BLANKVAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Fault B Filter Value</description>
            <name>FILTERVAL</name>
          </field>
        </fields>
        <name>FCTRLB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x14</addressOffset>
        <description>Waveform Extension Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Output Matrix</description>
            <name>OTMX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 0 Enable</description>
            <name>DTIEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 1 Enable</description>
            <name>DTIEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 2 Enable</description>
            <name>DTIEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 3 Enable</description>
            <name>DTIEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Dead-time Low Side Outputs Value</description>
            <name>DTLS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Dead-time High Side Outputs Value</description>
            <name>DTHS</name>
          </field>
        </fields>
        <name>WEXCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x18</addressOffset>
        <description>Driver Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 0 Output Enable</description>
            <name>NRE0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 1 Output Enable</description>
            <name>NRE1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 2 Output Enable</description>
            <name>NRE2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 3 Output Enable</description>
            <name>NRE3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 4 Output Enable</description>
            <name>NRE4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 5 Output Enable</description>
            <name>NRE5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 6 Output Enable</description>
            <name>NRE6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 7 Output Enable</description>
            <name>NRE7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 0 Output Value</description>
            <name>NRV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 1 Output Value</description>
            <name>NRV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 2 Output Value</description>
            <name>NRV2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 3 Output Value</description>
            <name>NRV3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 4 Output Value</description>
            <name>NRV4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 5 Output Value</description>
            <name>NRV5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 6 Output Value</description>
            <name>NRV6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 7 Output Value</description>
            <name>NRV7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 0 Inversion</description>
            <name>INVEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 1 Inversion</description>
            <name>INVEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 2 Inversion</description>
            <name>INVEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 3 Inversion</description>
            <name>INVEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x14</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 4 Inversion</description>
            <name>INVEN4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x15</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 5 Inversion</description>
            <name>INVEN5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 6 Inversion</description>
            <name>INVEN6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x17</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 7 Inversion</description>
            <name>INVEN7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Non-Recoverable Fault Input 0 Filter Value</description>
            <name>FILTERVAL0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Non-Recoverable Fault Input 1 Filter Value</description>
            <name>FILTERVAL1</name>
          </field>
        </fields>
        <name>DRVCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1E</addressOffset>
        <description>Debug Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Debug Running Mode</description>
            <name>DBGRUN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault Detection on Debug Break Detection</description>
            <name>FDDBD</name>
          </field>
        </fields>
        <name>DBGCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x20</addressOffset>
        <description>Event Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Timer/counter Input Event0 Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Event action disabled</description>
                <name>OFF</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Start, restart or re-trigger counter on event</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Count on event</description>
                <name>COUNTEV</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Start counter on event</description>
                <name>START</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Increment counter on event</description>
                <name>INC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Count on active state of asynchronous event</description>
                <name>COUNT</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>FAULT</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>EVACT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Timer/counter Input Event1 Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Event action disabled</description>
                <name>OFF</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Re-trigger counter on event</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Direction control</description>
                <name>DIR</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Stop counter on event</description>
                <name>STOP</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Decrement counter on event</description>
                <name>DEC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Period capture value in CC0 register, pulse width capture value in CC1 register</description>
                <name>PPW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Period capture value in CC1 register, pulse width capture value in CC0 register</description>
                <name>PWP</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>FAULT</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>EVACT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Timer/counter Output Event Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a new counter cycle starts</description>
                <name>START</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a counter cycle ends</description>
                <name>END</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a counter cycle ends, except for the first and last cycles</description>
                <name>BETWEEN</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a new counter cycle starts or a counter cycle ends</description>
                <name>BOUNDARY</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CNTSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow/Underflow Output Event Enable</description>
            <name>OVFEO</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger Output Event Enable</description>
            <name>TRGEO</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Timer/counter Output Event Enable</description>
            <name>CNTEO</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Inverted Event 0 Input Enable</description>
            <name>TCINV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Inverted Event 1 Input Enable</description>
            <name>TCINV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Timer/counter Event 0 Input Enable</description>
            <name>TCEI0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Timer/counter Event 1 Input Enable</description>
            <name>TCEI1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Event Input Enable</description>
            <name>MCEI0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Event Input Enable</description>
            <name>MCEI1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Event Input Enable</description>
            <name>MCEI2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Event Input Enable</description>
            <name>MCEI3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Event Output Enable</description>
            <name>MCEO0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Event Output Enable</description>
            <name>MCEO1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Event Output Enable</description>
            <name>MCEO2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Event Output Enable</description>
            <name>MCEO3</name>
          </field>
        </fields>
        <name>EVCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x24</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow Interrupt Enable</description>
            <name>OVF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger Interrupt Enable</description>
            <name>TRG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Interrupt Enable</description>
            <name>CNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error Interrupt Enable</description>
            <name>ERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault Interrupt Enable</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A Interrupt Enable</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B Interrupt Enable</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0 Interrupt Enable</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1 Interrupt Enable</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Interrupt Enable</description>
            <name>MC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Interrupt Enable</description>
            <name>MC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Interrupt Enable</description>
            <name>MC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Interrupt Enable</description>
            <name>MC3</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x28</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow Interrupt Enable</description>
            <name>OVF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger Interrupt Enable</description>
            <name>TRG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Interrupt Enable</description>
            <name>CNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error Interrupt Enable</description>
            <name>ERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault Interrupt Enable</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A Interrupt Enable</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B Interrupt Enable</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0 Interrupt Enable</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1 Interrupt Enable</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Interrupt Enable</description>
            <name>MC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Interrupt Enable</description>
            <name>MC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Interrupt Enable</description>
            <name>MC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Interrupt Enable</description>
            <name>MC3</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2C</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow</description>
            <name>OVF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger</description>
            <name>TRG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter</description>
            <name>CNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error</description>
            <name>ERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 0</description>
            <name>MC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 1</description>
            <name>MC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 2</description>
            <name>MC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 3</description>
            <name>MC3</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x30</addressOffset>
        <description>Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Stop</description>
            <name>STOP</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Ramp</description>
            <name>IDX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault State</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Slave</description>
            <name>SLAVE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Buffer Valid</description>
            <name>PATTBV</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wave Buffer Valid</description>
            <name>WAVEBV</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Period Buffer Valid</description>
            <name>PERBV</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A Input</description>
            <name>FAULTAIN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B Input</description>
            <name>FAULTBIN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault0 Input</description>
            <name>FAULT0IN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault1 Input</description>
            <name>FAULT1IN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A State</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B State</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0 State</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1 State</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 0 Buffer Valid</description>
            <name>CCBV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 1 Buffer Valid</description>
            <name>CCBV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 2 Buffer Valid</description>
            <name>CCBV2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 3 Buffer Valid</description>
            <name>CCBV3</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 0 Value</description>
            <name>CMP0</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 1 Value</description>
            <name>CMP1</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 2 Value</description>
            <name>CMP2</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 3 Value</description>
            <name>CMP3</name>
          </field>
        </fields>
        <name>STATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x1</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT_DITH4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT_DITH5</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT_DITH6</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x38</addressOffset>
        <description>Pattern</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Enable</description>
            <name>PGE0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Enable</description>
            <name>PGE1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Enable</description>
            <name>PGE2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Enable</description>
            <name>PGE3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Enable</description>
            <name>PGE4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Enable</description>
            <name>PGE5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Enable</description>
            <name>PGE6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Enable</description>
            <name>PGE7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Value</description>
            <name>PGV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Value</description>
            <name>PGV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Value</description>
            <name>PGV2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Value</description>
            <name>PGV3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Value</description>
            <name>PGV4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Value</description>
            <name>PGV5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Value</description>
            <name>PGV6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Value</description>
            <name>PGV7</name>
          </field>
        </fields>
        <name>PATT</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x3C</addressOffset>
        <description>Waveform Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Waveform Generation</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal frequency</description>
                <name>NFRQ</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Match frequency</description>
                <name>MFRQ</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal PWM</description>
                <name>NPWM</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope critical</description>
                <name>DSCRITICAL</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO</description>
                <name>DSBOTTOM</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO or TOP</description>
                <name>DSBOTH</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches TOP</description>
                <name>DSTOP</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WAVEGEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP1 operation</description>
                <name>RAMP1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternative RAMP2 operation</description>
                <name>RAMP2A</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP2 operation</description>
                <name>RAMP2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RAMP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular period Enable</description>
            <name>CIPEREN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 0 Enable</description>
            <name>CICCEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 1 Enable</description>
            <name>CICCEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 2 Enable</description>
            <name>CICCEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 3 Enable</description>
            <name>CICCEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Polarity</description>
            <name>POL0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Polarity</description>
            <name>POL1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Polarity</description>
            <name>POL2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Polarity</description>
            <name>POL3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 0</description>
            <name>SWAP0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 1</description>
            <name>SWAP1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 2</description>
            <name>SWAP2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 3</description>
            <name>SWAP3</name>
          </field>
        </fields>
        <name>WAVE</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER_DITH4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER_DITH5</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER_DITH6</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x64</addressOffset>
        <description>Pattern Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Enable Buffer</description>
            <name>PGEB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Enable Buffer</description>
            <name>PGEB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Enable Buffer</description>
            <name>PGEB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Enable Buffer</description>
            <name>PGEB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Enable Buffer</description>
            <name>PGEB4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Enable Buffer</description>
            <name>PGEB5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Enable Buffer</description>
            <name>PGEB6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Enable Buffer</description>
            <name>PGEB7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Enable</description>
            <name>PGVB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Enable</description>
            <name>PGVB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Enable</description>
            <name>PGVB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Enable</description>
            <name>PGVB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Enable</description>
            <name>PGVB4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Enable</description>
            <name>PGVB5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Enable</description>
            <name>PGVB6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Enable</description>
            <name>PGVB7</name>
          </field>
        </fields>
        <name>PATTB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x68</addressOffset>
        <description>Waveform Control Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Waveform Generation Buffer</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal frequency</description>
                <name>NFRQ</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Match frequency</description>
                <name>MFRQ</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal PWM</description>
                <name>NPWM</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope critical</description>
                <name>DSCRITICAL</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO</description>
                <name>DSBOTTOM</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO or TOP</description>
                <name>DSBOTH</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches TOP</description>
                <name>DSTOP</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WAVEGENB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Mode Buffer</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP1 operation</description>
                <name>RAMP1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternative RAMP2 operation</description>
                <name>RAMP2A</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP2 operation</description>
                <name>RAMP2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RAMPB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Period Enable Buffer</description>
            <name>CIPERENB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 0 Enable Buffer</description>
            <name>CICCENB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 1 Enable Buffer</description>
            <name>CICCENB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 2 Enable Buffer</description>
            <name>CICCENB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 3 Enable Buffer</description>
            <name>CICCENB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Polarity Buffer</description>
            <name>POLB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
