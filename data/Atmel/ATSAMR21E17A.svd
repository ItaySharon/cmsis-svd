            <description>Channel 1 Polarity Buffer</description>
            <name>POLB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Polarity Buffer</description>
            <name>POLB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Polarity Buffer</description>
            <name>POLB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 0 Buffer</description>
            <name>SWAPB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 1 Buffer</description>
            <name>SWAPB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 2 Buffer</description>
            <name>SWAPB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 3 Buffer</description>
            <name>SWAPB3</name>
          </field>
        </fields>
        <name>WAVEB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB_DITH4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB_DITH5</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB_DITH6</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x90</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42002400</baseAddress>
    <derivedFrom>TCC0</derivedFrom>
    <description>Timer Counter Control 1</description>
    <groupName>TCC</groupName>
    <interrupts>
      <interrupt>
        <name>TCC1_INTREQ</name>
        <value>0x10</value>
      </interrupt>
    </interrupts>
    <name>TCC1</name>
    <prependToName>TCC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control A</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Enhanced Resolution</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is disabled</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is done every 16 PWM frames</description>
                <name>DITH4</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is done every 32 PWM frames</description>
                <name>DITH5</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is done every 64 PWM frames</description>
                <name>DITH6</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RESOLUTION</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Prescaler</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No division</description>
                <name>DIV1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 2</description>
                <name>DIV2</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 4</description>
                <name>DIV4</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 8</description>
                <name>DIV8</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 16</description>
                <name>DIV16</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 64</description>
                <name>DIV64</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 256</description>
                <name>DIV256</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 1024</description>
                <name>DIV1024</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PRESCALER</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Prescaler and Counter Synchronization Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Reload or reset counter on next GCLK</description>
                <name>GCLK</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Reload or reset counter on next prescaler clock</description>
                <name>PRESC</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Reload or reset counter on next GCLK and reset prescaler counter</description>
                <name>RESYNC</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PRESCSYNC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Auto Lock</description>
            <name>ALOCK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 0 Enable</description>
            <name>CPTEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 1 Enable</description>
            <name>CPTEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 2 Enable</description>
            <name>CPTEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 3 Enable</description>
            <name>CPTEN3</name>
          </field>
        </fields>
        <name>CTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Control B Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Lock Update</description>
            <name>LUPD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>One-Shot</description>
            <name>ONESHOT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Index Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Command disabled: Index toggles between cycles A and B</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Set index: cycle B will be forced in the next cycle</description>
                <name>SET</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear index: cycle A will be forced in the next cycle</description>
                <name>CLEAR</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hold index: the next cycle will be the same as the current cycle</description>
                <name>HOLD</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>IDXCMD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>TCC Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No action</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear start, restart or retrigger</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force stop</description>
                <name>STOP</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force update of double buffered registers</description>
                <name>UPDATE</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force COUNT read synchronization</description>
                <name>READSYNC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CMD</name>
          </field>
        </fields>
        <name>CTRLBCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x5</addressOffset>
        <description>Control B Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Lock Update</description>
            <name>LUPD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>One-Shot</description>
            <name>ONESHOT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Index Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Command disabled: Index toggles between cycles A and B</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Set index: cycle B will be forced in the next cycle</description>
                <name>SET</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear index: cycle A will be forced in the next cycle</description>
                <name>CLEAR</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hold index: the next cycle will be the same as the current cycle</description>
                <name>HOLD</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>IDXCMD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>TCC Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No action</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear start, restart or retrigger</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force stop</description>
                <name>STOP</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force update of double buffered registers</description>
                <name>UPDATE</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force COUNT read synchronization</description>
                <name>READSYNC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CMD</name>
          </field>
        </fields>
        <name>CTRLBSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x8</addressOffset>
        <description>Synchronization Busy</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swrst Busy</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable Busy</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Ctrlb Busy</description>
            <name>CTRLB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Status Busy</description>
            <name>STATUS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Count Busy</description>
            <name>COUNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Busy</description>
            <name>PATT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wave Busy</description>
            <name>WAVE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Period busy</description>
            <name>PER</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 0 Busy</description>
            <name>CC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 1 Busy</description>
            <name>CC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 2 Busy</description>
            <name>CC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 3 Busy</description>
            <name>CC3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Buffer Busy</description>
            <name>PATTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wave Buffer Busy</description>
            <name>WAVEB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Period Buffer Busy</description>
            <name>PERB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 0 Busy</description>
            <name>CCB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x14</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 1 Busy</description>
            <name>CCB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x15</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 2 Busy</description>
            <name>CCB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 3 Busy</description>
            <name>CCB3</name>
          </field>
        </fields>
        <name>SYNCBUSY</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xC</addressOffset>
        <description>Recoverable Fault A Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Source</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Fault input disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>MCEx (x=0,1) event input</description>
                <name>ENABLE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Inverted MCEx (x=0,1) event input</description>
                <name>INVERT</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternate fault (A or B) state at the end of the previous period</description>
                <name>ALTFAULT</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SRC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault A Keeper</description>
            <name>KEEP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault A Qualification</description>
            <name>QUAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Blanking Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No blanking applied</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from rising edge of the output waveform</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from falling edge of the output waveform</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from each toggle of the output waveform</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>BLANK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault A Restart</description>
            <name>RESTART</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Halt Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Halt action disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hardware halt action</description>
                <name>HW</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Software halt action</description>
                <name>SW</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>NR</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>HALT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Capture Channel</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 0</description>
                <name>CC0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 1</description>
                <name>CC1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 2</description>
                <name>CC2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 3</description>
                <name>CC3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CHSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Fault A Capture Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No capture</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture on fault</description>
                <name>CAPT</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum capture</description>
                <name>CAPTMIN</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum capture</description>
                <name>CAPTMAX</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum local detection</description>
                <name>LOCMIN</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum local detection</description>
                <name>LOCMAX</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum and maximum local detection</description>
                <name>DERIV0</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CAPTURE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Fault A Blanking Time</description>
            <name>BLANKVAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Fault A Filter Value</description>
            <name>FILTERVAL</name>
          </field>
        </fields>
        <name>FCTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x10</addressOffset>
        <description>Recoverable Fault B Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Source</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Fault input disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>MCEx (x=0,1) event input</description>
                <name>ENABLE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Inverted MCEx (x=0,1) event input</description>
                <name>INVERT</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternate fault (A or B) state at the end of the previous period</description>
                <name>ALTFAULT</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SRC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault B Keeper</description>
            <name>KEEP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault B Qualification</description>
            <name>QUAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Blanking Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No blanking applied</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from rising edge of the output waveform</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from falling edge of the output waveform</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from each toggle of the output waveform</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>BLANK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault B Restart</description>
            <name>RESTART</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Halt Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Halt action disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hardware halt action</description>
                <name>HW</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Software halt action</description>
                <name>SW</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>NR</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>HALT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Capture Channel</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 0</description>
                <name>CC0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 1</description>
                <name>CC1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 2</description>
                <name>CC2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 3</description>
                <name>CC3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CHSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Fault B Capture Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No capture</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture on fault</description>
                <name>CAPT</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum capture</description>
                <name>CAPTMIN</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum capture</description>
                <name>CAPTMAX</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum local detection</description>
                <name>LOCMIN</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum local detection</description>
                <name>LOCMAX</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum and maximum local detection</description>
                <name>DERIV0</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CAPTURE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Fault B Blanking Time</description>
            <name>BLANKVAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Fault B Filter Value</description>
            <name>FILTERVAL</name>
          </field>
        </fields>
        <name>FCTRLB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x14</addressOffset>
        <description>Waveform Extension Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Output Matrix</description>
            <name>OTMX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 0 Enable</description>
            <name>DTIEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 1 Enable</description>
            <name>DTIEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 2 Enable</description>
            <name>DTIEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 3 Enable</description>
            <name>DTIEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Dead-time Low Side Outputs Value</description>
            <name>DTLS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Dead-time High Side Outputs Value</description>
            <name>DTHS</name>
          </field>
        </fields>
        <name>WEXCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x18</addressOffset>
        <description>Driver Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 0 Output Enable</description>
            <name>NRE0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 1 Output Enable</description>
            <name>NRE1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 2 Output Enable</description>
            <name>NRE2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 3 Output Enable</description>
            <name>NRE3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 4 Output Enable</description>
            <name>NRE4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 5 Output Enable</description>
            <name>NRE5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 6 Output Enable</description>
            <name>NRE6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 7 Output Enable</description>
            <name>NRE7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 0 Output Value</description>
            <name>NRV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 1 Output Value</description>
            <name>NRV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 2 Output Value</description>
            <name>NRV2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 3 Output Value</description>
            <name>NRV3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 4 Output Value</description>
            <name>NRV4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 5 Output Value</description>
            <name>NRV5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 6 Output Value</description>
            <name>NRV6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 7 Output Value</description>
            <name>NRV7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 0 Inversion</description>
            <name>INVEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 1 Inversion</description>
            <name>INVEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 2 Inversion</description>
            <name>INVEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 3 Inversion</description>
            <name>INVEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x14</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 4 Inversion</description>
            <name>INVEN4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x15</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 5 Inversion</description>
            <name>INVEN5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 6 Inversion</description>
            <name>INVEN6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x17</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 7 Inversion</description>
            <name>INVEN7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Non-Recoverable Fault Input 0 Filter Value</description>
            <name>FILTERVAL0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Non-Recoverable Fault Input 1 Filter Value</description>
            <name>FILTERVAL1</name>
          </field>
        </fields>
        <name>DRVCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1E</addressOffset>
        <description>Debug Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Debug Running Mode</description>
            <name>DBGRUN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault Detection on Debug Break Detection</description>
            <name>FDDBD</name>
          </field>
        </fields>
        <name>DBGCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x20</addressOffset>
        <description>Event Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Timer/counter Input Event0 Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Event action disabled</description>
                <name>OFF</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Start, restart or re-trigger counter on event</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Count on event</description>
                <name>COUNTEV</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Start counter on event</description>
                <name>START</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Increment counter on event</description>
                <name>INC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Count on active state of asynchronous event</description>
                <name>COUNT</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>FAULT</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>EVACT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Timer/counter Input Event1 Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Event action disabled</description>
                <name>OFF</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Re-trigger counter on event</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Direction control</description>
                <name>DIR</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Stop counter on event</description>
                <name>STOP</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Decrement counter on event</description>
                <name>DEC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Period capture value in CC0 register, pulse width capture value in CC1 register</description>
                <name>PPW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Period capture value in CC1 register, pulse width capture value in CC0 register</description>
                <name>PWP</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>FAULT</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>EVACT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Timer/counter Output Event Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a new counter cycle starts</description>
                <name>START</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a counter cycle ends</description>
                <name>END</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a counter cycle ends, except for the first and last cycles</description>
                <name>BETWEEN</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a new counter cycle starts or a counter cycle ends</description>
                <name>BOUNDARY</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CNTSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow/Underflow Output Event Enable</description>
            <name>OVFEO</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger Output Event Enable</description>
            <name>TRGEO</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Timer/counter Output Event Enable</description>
            <name>CNTEO</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Inverted Event 0 Input Enable</description>
            <name>TCINV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Inverted Event 1 Input Enable</description>
            <name>TCINV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Timer/counter Event 0 Input Enable</description>
            <name>TCEI0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Timer/counter Event 1 Input Enable</description>
            <name>TCEI1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Event Input Enable</description>
            <name>MCEI0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Event Input Enable</description>
            <name>MCEI1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Event Input Enable</description>
            <name>MCEI2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Event Input Enable</description>
            <name>MCEI3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Event Output Enable</description>
            <name>MCEO0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Event Output Enable</description>
            <name>MCEO1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Event Output Enable</description>
            <name>MCEO2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Event Output Enable</description>
            <name>MCEO3</name>
          </field>
        </fields>
        <name>EVCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x24</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow Interrupt Enable</description>
            <name>OVF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger Interrupt Enable</description>
            <name>TRG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Interrupt Enable</description>
            <name>CNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error Interrupt Enable</description>
            <name>ERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault Interrupt Enable</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A Interrupt Enable</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B Interrupt Enable</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0 Interrupt Enable</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1 Interrupt Enable</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Interrupt Enable</description>
            <name>MC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Interrupt Enable</description>
            <name>MC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Interrupt Enable</description>
            <name>MC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Interrupt Enable</description>
            <name>MC3</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x28</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow Interrupt Enable</description>
            <name>OVF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger Interrupt Enable</description>
            <name>TRG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Interrupt Enable</description>
            <name>CNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error Interrupt Enable</description>
            <name>ERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault Interrupt Enable</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A Interrupt Enable</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B Interrupt Enable</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0 Interrupt Enable</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1 Interrupt Enable</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Interrupt Enable</description>
            <name>MC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Interrupt Enable</description>
            <name>MC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Interrupt Enable</description>
            <name>MC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Interrupt Enable</description>
            <name>MC3</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2C</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow</description>
            <name>OVF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger</description>
            <name>TRG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter</description>
            <name>CNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error</description>
            <name>ERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 0</description>
            <name>MC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 1</description>
            <name>MC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 2</description>
            <name>MC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 3</description>
            <name>MC3</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x30</addressOffset>
        <description>Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Stop</description>
            <name>STOP</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Ramp</description>
            <name>IDX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault State</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Slave</description>
            <name>SLAVE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Buffer Valid</description>
            <name>PATTBV</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wave Buffer Valid</description>
            <name>WAVEBV</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Period Buffer Valid</description>
            <name>PERBV</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A Input</description>
            <name>FAULTAIN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B Input</description>
            <name>FAULTBIN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault0 Input</description>
            <name>FAULT0IN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault1 Input</description>
            <name>FAULT1IN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A State</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B State</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0 State</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1 State</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 0 Buffer Valid</description>
            <name>CCBV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 1 Buffer Valid</description>
            <name>CCBV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 2 Buffer Valid</description>
            <name>CCBV2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 3 Buffer Valid</description>
            <name>CCBV3</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 0 Value</description>
            <name>CMP0</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 1 Value</description>
            <name>CMP1</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 2 Value</description>
            <name>CMP2</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 3 Value</description>
            <name>CMP3</name>
          </field>
        </fields>
        <name>STATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x1</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT_DITH4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT_DITH5</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT_DITH6</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x38</addressOffset>
        <description>Pattern</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Enable</description>
            <name>PGE0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Enable</description>
            <name>PGE1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Enable</description>
            <name>PGE2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Enable</description>
            <name>PGE3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Enable</description>
            <name>PGE4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Enable</description>
            <name>PGE5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Enable</description>
            <name>PGE6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Enable</description>
            <name>PGE7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Value</description>
            <name>PGV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Value</description>
            <name>PGV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Value</description>
            <name>PGV2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Value</description>
            <name>PGV3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Value</description>
            <name>PGV4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Value</description>
            <name>PGV5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Value</description>
            <name>PGV6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Value</description>
            <name>PGV7</name>
          </field>
        </fields>
        <name>PATT</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x3C</addressOffset>
        <description>Waveform Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Waveform Generation</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal frequency</description>
                <name>NFRQ</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Match frequency</description>
                <name>MFRQ</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal PWM</description>
                <name>NPWM</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope critical</description>
                <name>DSCRITICAL</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO</description>
                <name>DSBOTTOM</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO or TOP</description>
                <name>DSBOTH</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches TOP</description>
                <name>DSTOP</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WAVEGEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP1 operation</description>
                <name>RAMP1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternative RAMP2 operation</description>
                <name>RAMP2A</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP2 operation</description>
                <name>RAMP2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RAMP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular period Enable</description>
            <name>CIPEREN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 0 Enable</description>
            <name>CICCEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 1 Enable</description>
            <name>CICCEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 2 Enable</description>
            <name>CICCEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 3 Enable</description>
            <name>CICCEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Polarity</description>
            <name>POL0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Polarity</description>
            <name>POL1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Polarity</description>
            <name>POL2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Polarity</description>
            <name>POL3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 0</description>
            <name>SWAP0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 1</description>
            <name>SWAP1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 2</description>
            <name>SWAP2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 3</description>
            <name>SWAP3</name>
          </field>
        </fields>
        <name>WAVE</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER_DITH4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER_DITH5</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER_DITH6</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x64</addressOffset>
        <description>Pattern Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Enable Buffer</description>
            <name>PGEB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Enable Buffer</description>
            <name>PGEB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Enable Buffer</description>
            <name>PGEB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Enable Buffer</description>
            <name>PGEB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Enable Buffer</description>
            <name>PGEB4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Enable Buffer</description>
            <name>PGEB5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Enable Buffer</description>
            <name>PGEB6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Enable Buffer</description>
            <name>PGEB7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Enable</description>
            <name>PGVB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Enable</description>
            <name>PGVB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Enable</description>
            <name>PGVB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Enable</description>
            <name>PGVB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Enable</description>
            <name>PGVB4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Enable</description>
            <name>PGVB5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Enable</description>
            <name>PGVB6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Enable</description>
            <name>PGVB7</name>
          </field>
        </fields>
        <name>PATTB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x68</addressOffset>
        <description>Waveform Control Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Waveform Generation Buffer</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal frequency</description>
                <name>NFRQ</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Match frequency</description>
                <name>MFRQ</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal PWM</description>
                <name>NPWM</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope critical</description>
                <name>DSCRITICAL</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO</description>
                <name>DSBOTTOM</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO or TOP</description>
                <name>DSBOTH</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches TOP</description>
                <name>DSTOP</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WAVEGENB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Mode Buffer</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP1 operation</description>
                <name>RAMP1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternative RAMP2 operation</description>
                <name>RAMP2A</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP2 operation</description>
                <name>RAMP2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RAMPB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Period Enable Buffer</description>
            <name>CIPERENB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 0 Enable Buffer</description>
            <name>CICCENB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 1 Enable Buffer</description>
            <name>CICCENB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 2 Enable Buffer</description>
            <name>CICCENB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 3 Enable Buffer</description>
            <name>CICCENB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Polarity Buffer</description>
            <name>POLB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Polarity Buffer</description>
            <name>POLB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Polarity Buffer</description>
            <name>POLB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Polarity Buffer</description>
            <name>POLB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 0 Buffer</description>
            <name>SWAPB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 1 Buffer</description>
            <name>SWAPB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 2 Buffer</description>
            <name>SWAPB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 3 Buffer</description>
            <name>SWAPB3</name>
          </field>
        </fields>
        <name>WAVEB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB_DITH4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB_DITH5</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB_DITH6</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x90</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x42002800</baseAddress>
    <derivedFrom>TCC0</derivedFrom>
    <description>Timer Counter Control 2</description>
    <groupName>TCC</groupName>
    <interrupts>
      <interrupt>
        <name>TCC2_INTREQ</name>
        <value>0x11</value>
      </interrupt>
    </interrupts>
    <name>TCC2</name>
    <prependToName>TCC_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control A</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Software Reset</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Enhanced Resolution</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is disabled</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is done every 16 PWM frames</description>
                <name>DITH4</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is done every 32 PWM frames</description>
                <name>DITH5</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dithering is done every 64 PWM frames</description>
                <name>DITH6</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RESOLUTION</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Prescaler</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No division</description>
                <name>DIV1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 2</description>
                <name>DIV2</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 4</description>
                <name>DIV4</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 8</description>
                <name>DIV8</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 16</description>
                <name>DIV16</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 64</description>
                <name>DIV64</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 256</description>
                <name>DIV256</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Divide by 1024</description>
                <name>DIV1024</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PRESCALER</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Run in Standby</description>
            <name>RUNSTDBY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Prescaler and Counter Synchronization Selection</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Reload or reset counter on next GCLK</description>
                <name>GCLK</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Reload or reset counter on next prescaler clock</description>
                <name>PRESC</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Reload or reset counter on next GCLK and reset prescaler counter</description>
                <name>RESYNC</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PRESCSYNC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Auto Lock</description>
            <name>ALOCK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 0 Enable</description>
            <name>CPTEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 1 Enable</description>
            <name>CPTEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 2 Enable</description>
            <name>CPTEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Capture Channel 3 Enable</description>
            <name>CPTEN3</name>
          </field>
        </fields>
        <name>CTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Control B Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Lock Update</description>
            <name>LUPD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>One-Shot</description>
            <name>ONESHOT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Index Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Command disabled: Index toggles between cycles A and B</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Set index: cycle B will be forced in the next cycle</description>
                <name>SET</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear index: cycle A will be forced in the next cycle</description>
                <name>CLEAR</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hold index: the next cycle will be the same as the current cycle</description>
                <name>HOLD</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>IDXCMD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>TCC Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No action</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear start, restart or retrigger</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force stop</description>
                <name>STOP</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force update of double buffered registers</description>
                <name>UPDATE</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force COUNT read synchronization</description>
                <name>READSYNC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CMD</name>
          </field>
        </fields>
        <name>CTRLBCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x5</addressOffset>
        <description>Control B Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Direction</description>
            <name>DIR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Lock Update</description>
            <name>LUPD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>One-Shot</description>
            <name>ONESHOT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Index Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Command disabled: Index toggles between cycles A and B</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Set index: cycle B will be forced in the next cycle</description>
                <name>SET</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear index: cycle A will be forced in the next cycle</description>
                <name>CLEAR</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hold index: the next cycle will be the same as the current cycle</description>
                <name>HOLD</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>IDXCMD</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>TCC Command</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No action</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear start, restart or retrigger</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force stop</description>
                <name>STOP</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force update of double buffered registers</description>
                <name>UPDATE</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Force COUNT read synchronization</description>
                <name>READSYNC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CMD</name>
          </field>
        </fields>
        <name>CTRLBSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x8</addressOffset>
        <description>Synchronization Busy</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swrst Busy</description>
            <name>SWRST</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable Busy</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Ctrlb Busy</description>
            <name>CTRLB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Status Busy</description>
            <name>STATUS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Count Busy</description>
            <name>COUNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Busy</description>
            <name>PATT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wave Busy</description>
            <name>WAVE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Period busy</description>
            <name>PER</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 0 Busy</description>
            <name>CC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 1 Busy</description>
            <name>CC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 2 Busy</description>
            <name>CC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 3 Busy</description>
            <name>CC3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Buffer Busy</description>
            <name>PATTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wave Buffer Busy</description>
            <name>WAVEB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Period Buffer Busy</description>
            <name>PERB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 0 Busy</description>
            <name>CCB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x14</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 1 Busy</description>
            <name>CCB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x15</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 2 Busy</description>
            <name>CCB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel Buffer 3 Busy</description>
            <name>CCB3</name>
          </field>
        </fields>
        <name>SYNCBUSY</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0xC</addressOffset>
        <description>Recoverable Fault A Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Source</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Fault input disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>MCEx (x=0,1) event input</description>
                <name>ENABLE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Inverted MCEx (x=0,1) event input</description>
                <name>INVERT</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternate fault (A or B) state at the end of the previous period</description>
                <name>ALTFAULT</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SRC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault A Keeper</description>
            <name>KEEP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault A Qualification</description>
            <name>QUAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Blanking Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No blanking applied</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from rising edge of the output waveform</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from falling edge of the output waveform</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from each toggle of the output waveform</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>BLANK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault A Restart</description>
            <name>RESTART</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Halt Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Halt action disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hardware halt action</description>
                <name>HW</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Software halt action</description>
                <name>SW</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>NR</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>HALT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault A Capture Channel</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 0</description>
                <name>CC0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 1</description>
                <name>CC1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 2</description>
                <name>CC2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 3</description>
                <name>CC3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CHSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Fault A Capture Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No capture</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture on fault</description>
                <name>CAPT</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum capture</description>
                <name>CAPTMIN</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum capture</description>
                <name>CAPTMAX</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum local detection</description>
                <name>LOCMIN</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum local detection</description>
                <name>LOCMAX</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum and maximum local detection</description>
                <name>DERIV0</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CAPTURE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Fault A Blanking Time</description>
            <name>BLANKVAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Fault A Filter Value</description>
            <name>FILTERVAL</name>
          </field>
        </fields>
        <name>FCTRLA</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x10</addressOffset>
        <description>Recoverable Fault B Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Source</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Fault input disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>MCEx (x=0,1) event input</description>
                <name>ENABLE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Inverted MCEx (x=0,1) event input</description>
                <name>INVERT</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternate fault (A or B) state at the end of the previous period</description>
                <name>ALTFAULT</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>SRC</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault B Keeper</description>
            <name>KEEP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault B Qualification</description>
            <name>QUAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Blanking Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No blanking applied</description>
                <name>NONE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from rising edge of the output waveform</description>
                <name>RISE</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from falling edge of the output waveform</description>
                <name>FALL</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Blanking applied from each toggle of the output waveform</description>
                <name>BOTH</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>BLANK</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault B Restart</description>
            <name>RESTART</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Halt Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Halt action disabled</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Hardware halt action</description>
                <name>HW</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Software halt action</description>
                <name>SW</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>NR</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>HALT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Fault B Capture Channel</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 0</description>
                <name>CC0</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 1</description>
                <name>CC1</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 2</description>
                <name>CC2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture value stored in channel 3</description>
                <name>CC3</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CHSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Fault B Capture Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>No capture</description>
                <name>DISABLE</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Capture on fault</description>
                <name>CAPT</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum capture</description>
                <name>CAPTMIN</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum capture</description>
                <name>CAPTMAX</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum local detection</description>
                <name>LOCMIN</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Maximum local detection</description>
                <name>LOCMAX</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Minimum and maximum local detection</description>
                <name>DERIV0</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CAPTURE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Fault B Blanking Time</description>
            <name>BLANKVAL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Fault B Filter Value</description>
            <name>FILTERVAL</name>
          </field>
        </fields>
        <name>FCTRLB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x14</addressOffset>
        <description>Waveform Extension Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Output Matrix</description>
            <name>OTMX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 0 Enable</description>
            <name>DTIEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 1 Enable</description>
            <name>DTIEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 2 Enable</description>
            <name>DTIEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Dead-time Insertion Generator 3 Enable</description>
            <name>DTIEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Dead-time Low Side Outputs Value</description>
            <name>DTLS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Dead-time High Side Outputs Value</description>
            <name>DTHS</name>
          </field>
        </fields>
        <name>WEXCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x18</addressOffset>
        <description>Driver Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 0 Output Enable</description>
            <name>NRE0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 1 Output Enable</description>
            <name>NRE1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 2 Output Enable</description>
            <name>NRE2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 3 Output Enable</description>
            <name>NRE3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 4 Output Enable</description>
            <name>NRE4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 5 Output Enable</description>
            <name>NRE5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 6 Output Enable</description>
            <name>NRE6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 7 Output Enable</description>
            <name>NRE7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 0 Output Value</description>
            <name>NRV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 1 Output Value</description>
            <name>NRV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 2 Output Value</description>
            <name>NRV2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 3 Output Value</description>
            <name>NRV3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 4 Output Value</description>
            <name>NRV4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 5 Output Value</description>
            <name>NRV5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 6 Output Value</description>
            <name>NRV6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable State 7 Output Value</description>
            <name>NRV7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 0 Inversion</description>
            <name>INVEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 1 Inversion</description>
            <name>INVEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 2 Inversion</description>
            <name>INVEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 3 Inversion</description>
            <name>INVEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x14</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 4 Inversion</description>
            <name>INVEN4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x15</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 5 Inversion</description>
            <name>INVEN5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x16</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 6 Inversion</description>
            <name>INVEN6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x17</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Output Waveform 7 Inversion</description>
            <name>INVEN7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Non-Recoverable Fault Input 0 Filter Value</description>
            <name>FILTERVAL0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1C</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Non-Recoverable Fault Input 1 Filter Value</description>
            <name>FILTERVAL1</name>
          </field>
        </fields>
        <name>DRVCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1E</addressOffset>
        <description>Debug Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Debug Running Mode</description>
            <name>DBGRUN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Fault Detection on Debug Break Detection</description>
            <name>FDDBD</name>
          </field>
        </fields>
        <name>DBGCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x20</addressOffset>
        <description>Event Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Timer/counter Input Event0 Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Event action disabled</description>
                <name>OFF</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Start, restart or re-trigger counter on event</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Count on event</description>
                <name>COUNTEV</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Start counter on event</description>
                <name>START</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Increment counter on event</description>
                <name>INC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Count on active state of asynchronous event</description>
                <name>COUNT</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>FAULT</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>EVACT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Timer/counter Input Event1 Action</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Event action disabled</description>
                <name>OFF</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Re-trigger counter on event</description>
                <name>RETRIGGER</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Direction control</description>
                <name>DIR</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Stop counter on event</description>
                <name>STOP</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Decrement counter on event</description>
                <name>DEC</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Period capture value in CC0 register, pulse width capture value in CC1 register</description>
                <name>PPW</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Period capture value in CC1 register, pulse width capture value in CC0 register</description>
                <name>PWP</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Non-recoverable fault</description>
                <name>FAULT</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>EVACT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Timer/counter Output Event Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a new counter cycle starts</description>
                <name>START</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a counter cycle ends</description>
                <name>END</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a counter cycle ends, except for the first and last cycles</description>
                <name>BETWEEN</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>An interrupt/event is generated when a new counter cycle starts or a counter cycle ends</description>
                <name>BOUNDARY</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CNTSEL</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow/Underflow Output Event Enable</description>
            <name>OVFEO</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger Output Event Enable</description>
            <name>TRGEO</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Timer/counter Output Event Enable</description>
            <name>CNTEO</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Inverted Event 0 Input Enable</description>
            <name>TCINV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Inverted Event 1 Input Enable</description>
            <name>TCINV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Timer/counter Event 0 Input Enable</description>
            <name>TCEI0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Timer/counter Event 1 Input Enable</description>
            <name>TCEI1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Event Input Enable</description>
            <name>MCEI0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Event Input Enable</description>
            <name>MCEI1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Event Input Enable</description>
            <name>MCEI2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Event Input Enable</description>
            <name>MCEI3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Event Output Enable</description>
            <name>MCEO0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Event Output Enable</description>
            <name>MCEO1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Event Output Enable</description>
            <name>MCEO2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Event Output Enable</description>
            <name>MCEO3</name>
          </field>
        </fields>
        <name>EVCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x24</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow Interrupt Enable</description>
            <name>OVF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger Interrupt Enable</description>
            <name>TRG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Interrupt Enable</description>
            <name>CNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error Interrupt Enable</description>
            <name>ERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault Interrupt Enable</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A Interrupt Enable</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B Interrupt Enable</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0 Interrupt Enable</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1 Interrupt Enable</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Interrupt Enable</description>
            <name>MC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Interrupt Enable</description>
            <name>MC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Interrupt Enable</description>
            <name>MC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Interrupt Enable</description>
            <name>MC3</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x28</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow Interrupt Enable</description>
            <name>OVF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger Interrupt Enable</description>
            <name>TRG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter Interrupt Enable</description>
            <name>CNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error Interrupt Enable</description>
            <name>ERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault Interrupt Enable</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A Interrupt Enable</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B Interrupt Enable</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0 Interrupt Enable</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1 Interrupt Enable</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 0 Interrupt Enable</description>
            <name>MC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 1 Interrupt Enable</description>
            <name>MC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 2 Interrupt Enable</description>
            <name>MC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture Channel 3 Interrupt Enable</description>
            <name>MC3</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2C</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Overflow</description>
            <name>OVF</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Retrigger</description>
            <name>TRG</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Counter</description>
            <name>CNT</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Error</description>
            <name>ERR</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 0</description>
            <name>MC0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 1</description>
            <name>MC1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 2</description>
            <name>MC2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Match or Capture 3</description>
            <name>MC3</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x30</addressOffset>
        <description>Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Stop</description>
            <name>STOP</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Ramp</description>
            <name>IDX</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Debug Fault State</description>
            <name>DFS</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Slave</description>
            <name>SLAVE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Buffer Valid</description>
            <name>PATTBV</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Wave Buffer Valid</description>
            <name>WAVEBV</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Period Buffer Valid</description>
            <name>PERBV</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A Input</description>
            <name>FAULTAIN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B Input</description>
            <name>FAULTBIN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault0 Input</description>
            <name>FAULT0IN</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault1 Input</description>
            <name>FAULT1IN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault A State</description>
            <name>FAULTA</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Recoverable Fault B State</description>
            <name>FAULTB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 0 State</description>
            <name>FAULT0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Non-Recoverable Fault 1 State</description>
            <name>FAULT1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 0 Buffer Valid</description>
            <name>CCBV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 1 Buffer Valid</description>
            <name>CCBV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 2 Buffer Valid</description>
            <name>CCBV2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 3 Buffer Valid</description>
            <name>CCBV3</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 0 Value</description>
            <name>CMP0</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 1 Value</description>
            <name>CMP1</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 2 Value</description>
            <name>CMP2</name>
          </field>
        </fields>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Compare Channel 3 Value</description>
            <name>CMP3</name>
          </field>
        </fields>
        <name>STATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x1</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT_DITH4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT_DITH5</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x34</addressOffset>
        <description>Count</description>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Counter Value</description>
            <name>COUNT</name>
          </field>
        </fields>
        <name>COUNT_DITH6</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x38</addressOffset>
        <description>Pattern</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Enable</description>
            <name>PGE0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Enable</description>
            <name>PGE1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Enable</description>
            <name>PGE2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Enable</description>
            <name>PGE3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Enable</description>
            <name>PGE4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Enable</description>
            <name>PGE5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Enable</description>
            <name>PGE6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Enable</description>
            <name>PGE7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Value</description>
            <name>PGV0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Value</description>
            <name>PGV1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Value</description>
            <name>PGV2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Value</description>
            <name>PGV3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Value</description>
            <name>PGV4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Value</description>
            <name>PGV5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Value</description>
            <name>PGV6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Value</description>
            <name>PGV7</name>
          </field>
        </fields>
        <name>PATT</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x3C</addressOffset>
        <description>Waveform Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Waveform Generation</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal frequency</description>
                <name>NFRQ</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Match frequency</description>
                <name>MFRQ</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal PWM</description>
                <name>NPWM</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope critical</description>
                <name>DSCRITICAL</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO</description>
                <name>DSBOTTOM</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO or TOP</description>
                <name>DSBOTH</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches TOP</description>
                <name>DSTOP</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WAVEGEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Mode</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP1 operation</description>
                <name>RAMP1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternative RAMP2 operation</description>
                <name>RAMP2A</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP2 operation</description>
                <name>RAMP2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RAMP</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular period Enable</description>
            <name>CIPEREN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 0 Enable</description>
            <name>CICCEN0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 1 Enable</description>
            <name>CICCEN1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 2 Enable</description>
            <name>CICCEN2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 3 Enable</description>
            <name>CICCEN3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Polarity</description>
            <name>POL0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Polarity</description>
            <name>POL1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Polarity</description>
            <name>POL2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Polarity</description>
            <name>POL3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 0</description>
            <name>SWAP0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 1</description>
            <name>SWAP1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 2</description>
            <name>SWAP2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 3</description>
            <name>SWAP3</name>
          </field>
        </fields>
        <name>WAVE</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER_DITH4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER_DITH5</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x40</addressOffset>
        <description>Period</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Period Value</description>
            <name>PER</name>
          </field>
        </fields>
        <name>PER_DITH6</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x64</addressOffset>
        <description>Pattern Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Enable Buffer</description>
            <name>PGEB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Enable Buffer</description>
            <name>PGEB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Enable Buffer</description>
            <name>PGEB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x3</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Enable Buffer</description>
            <name>PGEB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Enable Buffer</description>
            <name>PGEB4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Enable Buffer</description>
            <name>PGEB5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Enable Buffer</description>
            <name>PGEB6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Enable Buffer</description>
            <name>PGEB7</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 0 Output Enable</description>
            <name>PGVB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 1 Output Enable</description>
            <name>PGVB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 2 Output Enable</description>
            <name>PGVB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 3 Output Enable</description>
            <name>PGVB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xC</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 4 Output Enable</description>
            <name>PGVB4</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xD</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 5 Output Enable</description>
            <name>PGVB5</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xE</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 6 Output Enable</description>
            <name>PGVB6</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xF</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Pattern Generator 7 Output Enable</description>
            <name>PGVB7</name>
          </field>
        </fields>
        <name>PATTB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x10</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x68</addressOffset>
        <description>Waveform Control Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x3</bitWidth>
            <description>Waveform Generation Buffer</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal frequency</description>
                <name>NFRQ</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Match frequency</description>
                <name>MFRQ</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Normal PWM</description>
                <name>NPWM</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope critical</description>
                <name>DSCRITICAL</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO</description>
                <name>DSBOTTOM</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches ZERO or TOP</description>
                <name>DSBOTH</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Dual-slope with interrupt/event condition when COUNT reaches TOP</description>
                <name>DSTOP</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WAVEGENB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x2</bitWidth>
            <description>Ramp Mode Buffer</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP1 operation</description>
                <name>RAMP1</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>Alternative RAMP2 operation</description>
                <name>RAMP2A</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>RAMP2 operation</description>
                <name>RAMP2</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>RAMPB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Period Enable Buffer</description>
            <name>CIPERENB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x8</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 0 Enable Buffer</description>
            <name>CICCENB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x9</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 1 Enable Buffer</description>
            <name>CICCENB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xA</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 2 Enable Buffer</description>
            <name>CICCENB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0xB</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Circular Channel 3 Enable Buffer</description>
            <name>CICCENB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x10</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 0 Polarity Buffer</description>
            <name>POLB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x11</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 1 Polarity Buffer</description>
            <name>POLB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x12</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 2 Polarity Buffer</description>
            <name>POLB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x13</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Channel 3 Polarity Buffer</description>
            <name>POLB3</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x18</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 0 Buffer</description>
            <name>SWAPB0</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x19</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 1 Buffer</description>
            <name>SWAPB1</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1A</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 2 Buffer</description>
            <name>SWAPB2</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x1B</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Swap DTI Output Pair 3 Buffer</description>
            <name>SWAPB3</name>
          </field>
        </fields>
        <name>WAVEB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB_DITH4</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB_DITH5</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6C</addressOffset>
        <description>Period Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Period Buffer Value</description>
            <name>PERB</name>
          </field>
        </fields>
        <name>PERB_DITH6</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xFFFFFFFF</resetValue>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x44</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC0_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x48</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC1_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x4C</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC2_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x50</addressOffset>
        <description>Compare and Capture</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Cycle Number</description>
            <name>DITHERCY</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Value</description>
            <name>CC</name>
          </field>
        </fields>
        <name>CC3_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x18</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x14</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH4</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x5</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x5</bitOffset>
            <bitWidth>0x13</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH5</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x70</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB0_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x74</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB1_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x78</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB2_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <registers>
      <register>
        <addressOffset>0x7C</addressOffset>
        <description>Compare and Capture Buffer</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x6</bitWidth>
            <description>Dithering Buffer Cycle Number</description>
            <name>DITHERCYB</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x6</bitOffset>
            <bitWidth>0x12</bitWidth>
            <description>Channel Compare/Capture Buffer Value</description>
            <name>CCB</name>
          </field>
        </fields>
        <name>CCB3_DITH6</name>
        <size>0x20</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x1000</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x41005000</baseAddress>
    <description>Universal Serial Bus</description>
    <groupName>USB</groupName>
    <interrupts>
      <interrupt>
        <name>USB_INTREQ</name>
        <value>0x7</value>
      </interrupt>
    </interrupts>
    <name>USB</name>
    <prependToName>USB_</prependToName>
    <registers></registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>1.0.1</version>
  </peripheral>
</peripherals>
<peripherals>
  <peripheral>
    <access>read-write</access>
    <addressBlock>
      <offset>0x0</offset>
      <size>0x10</size>
      <usage>registers</usage>
    </addressBlock>
    <baseAddress>0x40001000</baseAddress>
    <description>Watchdog Timer</description>
    <groupName>WDT</groupName>
    <interrupts>
      <interrupt>
        <name>WDT_INTREQ</name>
        <value>0x2</value>
      </interrupt>
    </interrupts>
    <name>WDT</name>
    <prependToName>WDT_</prependToName>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x0</addressOffset>
        <description>Control</description>
        <fields>
          <field>
            <bitOffset>0x1</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Enable</description>
            <name>ENABLE</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x2</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Watchdog Timer Window Mode Enable</description>
            <name>WEN</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Always-On</description>
            <name>ALWAYSON</name>
          </field>
        </fields>
        <name>CTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x1</addressOffset>
        <description>Configuration</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Time-Out Period</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>8 clock cycles</description>
                <name>8</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16 clock cycles</description>
                <name>16</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>32 clock cycles</description>
                <name>32</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>64 clock cycles</description>
                <name>64</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>128 clock cycles</description>
                <name>128</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>256 clock cycles</description>
                <name>256</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>512 clock cycles</description>
                <name>512</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>1024 clock cycles</description>
                <name>1K</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>2048 clock cycles</description>
                <name>2K</name>
                <value>0x8</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>4096 clock cycles</description>
                <name>4K</name>
                <value>0x9</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>8192 clock cycles</description>
                <name>8K</name>
                <value>0xA</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16384 clock cycles</description>
                <name>16K</name>
                <value>0xB</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>PER</name>
          </field>
        </fields>
        <fields>
          <field>
            <bitOffset>0x4</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Window Mode Time-Out Period</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>8 clock cycles</description>
                <name>8</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16 clock cycles</description>
                <name>16</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>32 clock cycles</description>
                <name>32</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>64 clock cycles</description>
                <name>64</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>128 clock cycles</description>
                <name>128</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>256 clock cycles</description>
                <name>256</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>512 clock cycles</description>
                <name>512</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>1024 clock cycles</description>
                <name>1K</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>2048 clock cycles</description>
                <name>2K</name>
                <value>0x8</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>4096 clock cycles</description>
                <name>4K</name>
                <value>0x9</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>8192 clock cycles</description>
                <name>8K</name>
                <value>0xA</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16384 clock cycles</description>
                <name>16K</name>
                <value>0xB</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>WINDOW</name>
          </field>
        </fields>
        <name>CONFIG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xBB</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x2</addressOffset>
        <description>Early Warning Interrupt Control</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x4</bitWidth>
            <description>Early Warning Interrupt Time Offset</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>8 clock cycles</description>
                <name>8</name>
                <value>0x0</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16 clock cycles</description>
                <name>16</name>
                <value>0x1</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>32 clock cycles</description>
                <name>32</name>
                <value>0x2</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>64 clock cycles</description>
                <name>64</name>
                <value>0x3</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>128 clock cycles</description>
                <name>128</name>
                <value>0x4</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>256 clock cycles</description>
                <name>256</name>
                <value>0x5</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>512 clock cycles</description>
                <name>512</name>
                <value>0x6</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>1024 clock cycles</description>
                <name>1K</name>
                <value>0x7</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>2048 clock cycles</description>
                <name>2K</name>
                <value>0x8</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>4096 clock cycles</description>
                <name>4K</name>
                <value>0x9</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>8192 clock cycles</description>
                <name>8K</name>
                <value>0xA</value>
              </enumeratedValue>
            </enumeratedValues>
            <enumeratedValues>
              <enumeratedValue>
                <description>16384 clock cycles</description>
                <name>16K</name>
                <value>0xB</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>EWOFFSET</name>
          </field>
        </fields>
        <name>EWCTRL</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0xB</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x4</addressOffset>
        <description>Interrupt Enable Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Early Warning Interrupt Enable</description>
            <name>EW</name>
          </field>
        </fields>
        <name>INTENCLR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x5</addressOffset>
        <description>Interrupt Enable Set</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Early Warning Interrupt Enable</description>
            <name>EW</name>
          </field>
        </fields>
        <name>INTENSET</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-write</access>
        <addressOffset>0x6</addressOffset>
        <description>Interrupt Flag Status and Clear</description>
        <fields>
          <field>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Early Warning</description>
            <name>EW</name>
          </field>
        </fields>
        <name>INTFLAG</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>read-only</access>
        <addressOffset>0x7</addressOffset>
        <description>Status</description>
        <fields>
          <field>
            <access>read-only</access>
            <bitOffset>0x7</bitOffset>
            <bitWidth>0x1</bitWidth>
            <description>Synchronization Busy</description>
            <name>SYNCBUSY</name>
          </field>
        </fields>
        <name>STATUS</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <registers>
      <register>
        <access>write-only</access>
        <addressOffset>0x8</addressOffset>
        <description>Clear</description>
        <fields>
          <field>
            <access>write-only</access>
            <bitOffset>0x0</bitOffset>
            <bitWidth>0x8</bitWidth>
            <description>Watchdog Clear</description>
            <enumeratedValues>
              <enumeratedValue>
                <description>Clear Key</description>
                <name>KEY</name>
                <value>0xA5</value>
              </enumeratedValue>
            </enumeratedValues>
            <name>CLEAR</name>
          </field>
        </fields>
        <name>CLEAR</name>
        <resetMask>0xFFFFFFFF</resetMask>
        <resetValue>0x0</resetValue>
        <size>0x8</size>
      </register>
    </registers>
    <resetMask>0xFFFFFFFF</resetMask>
    <resetValue>0x0</resetValue>
    <size>0x20</size>
    <version>2.0.0</version>
  </peripheral>
</peripherals>
<resetMask>0xFFFFFFFF</resetMask>
<resetValue>0x0</resetValue>
<size>0x20</size>
<vendor>Atmel Corporation</vendor>
<vendorId>ATMEL</vendorId>
<version>D</version>
<width>0x20</width></device>